// SPDX-License-Identifier: BSD-3-Clause
/*
 * Samsung Galaxy Tab S9 Ultra Wi-Fi (SM-X910 / gts9uwifi) device tree.
 *
 * Authored from the live stock Samsung gts9u r03 device-tree
 * (overlay1.dts, board-id 0x10008,0x03, extracted off-device)
 * by downstream-5.15 -> mainline-7.0 binding translation, on a pristine
 * torvalds v7.0 (028ef9c96e) base, q5q (the only upstream Samsung
 * SM8550 DTS) as the structural pattern.
 *
 * Copyright (c) 2026, ubuntu-tab project.
 * Copyright (c) 2024, Alexandru Marc Serdeliuc / David Wronek (q5q pattern).
 * Copyright (c) 2022, Linaro Limited (sm8550.dtsi).
 */

/dts-v1/;

#include <dt-bindings/pinctrl/qcom,pmic-gpio.h>
#include <dt-bindings/regulator/qcom,rpmh-regulator.h>
#include <dt-bindings/sound/cs35l45.h>

/*
 * Battery Protection Engine, transcribed from this device's own stock dtbo.
 *
 * Stock programs BPE and boost-BPE on all four amplifiers and the values are
 * IDENTICAL on every one -- verified by decompiling both stock overlays, which
 * are themselves byte-identical in this region. That sameness is expressed here
 * as a macro so it stays a fact about the design rather than four copies that
 * can drift apart.
 *
 * BPE watches the battery rail VP against four thresholds and applies a
 * per-level output attenuation; boost-BPE drives the boost converter's current
 * limits from the same ladder. Mainline configured none of it before.
 *
 * 🔴 bpe-filt-sel and bpe-mode-sel are declared here because STOCK'S DEVICE TREE
 * DECLARES THEM -- this node is a faithful copy of stock's. They are, however,
 * NEVER APPLIED, on stock or here: the vendor driver looks them up as
 * "bst-bpe-mode-sel"/"bst-bpe-filt-sel", names that belong to the separate
 * bst-bpe-misc-config node and do not exist in this one, so its lookups fail
 * and the two register fields keep their reset value. Our driver reproduces
 * that omission deliberately (see cs35l45_bpe_misc_props). Keeping the
 * properties here and not reading them is what makes the DT match stock's DT
 * and the behaviour match stock's behaviour, which are two different things.
 */
#define CS35L45_GTS9U_BPE_CONFIG					\
	cirrus,bpe-inst-config {					\
		bpe-inst-thld = <0x1e 0x28 0x46 0x5a>;			\
		bpe-inst-attn = <0x0a 0x06 0x0c 0x06>;			\
		bpe-inst-atk-rate = <0x00 0x01 0x06 0x06>;		\
		bpe-inst-hold-time = <0x02 0x02 0x02 0x02>;		\
		bpe-inst-rls-rate = <0x0a 0x08 0x05 0x05>;		\
	};								\
									\
	cirrus,bpe-misc-config {					\
		bpe-filt-sel = <0x00>;					\
		bpe-mode-sel = <0x00>;					\
		bpe-inst-l1-byp = <0x00>;				\
		bpe-inst-l2-byp = <0x01>;				\
		bpe-inst-l3-byp = <0x01>;				\
		bpe-inst-inf-hold-rls = <0x00>;				\
		bpe-inst-bpe-byp = <0x00>;				\
	};								\
									\
	cirrus,bst-bpe-inst-config {					\
		bst-bpe-inst-thld = <0x1e 0x28 0x46 0x5a 0x00>;		\
		bst-bpe-inst-ilim = <0x00 0x04 0x0c 0x14 0x3c>;		\
		bst-bpe-inst-ss-ilim = <0x00 0x00 0x04 0x08 0x1c>;	\
		bst-bpe-inst-atk-rate = <0x00 0x03 0x06 0x06 0x00>;	\
		bst-bpe-inst-hold-time = <0x02 0x02 0x02 0x02 0x00>;	\
		bst-bpe-inst-rls-rate = <0x06 0x06 0x06 0x06 0x00>;	\
	};								\
									\
	cirrus,bst-bpe-misc-config {					\
		bst-bpe-filt-sel = <0x00>;				\
		bst-bpe-inst-l1-byp = <0x00>;				\
		bst-bpe-inst-l2-byp = <0x01>;				\
		bst-bpe-inst-l3-byp = <0x01>;				\
		bst-bpe-out-opmode-sel = <0x00>;			\
		bst-bpe-il-lim-mode = <0x00>;				\
		bst-bpe-inst-inf-hold-rls = <0x00>;			\
	};								\
									\
	cirrus,bst-bpe-il-lim-config {					\
		bst-bpe-il-lim1-dly = <0x04>;				\
		bst-bpe-il-lim2-dly = <0x04>;				\
		bst-bpe-il-lim-dly-hyst = <0x00>;			\
		bst-bpe-il-lim-thld-hyst = <0x00>;			\
		bst-bpe-il-lim1-thld = <0x2c>;				\
		bst-bpe-il-lim-thld-del2 = <0x00>;			\
		bst-bpe-il-lim-thld-del1 = <0x10>;			\
	};

#define CS35L45_GTS9U_POWER_MODE_CONFIG				\
	cirrus,hvlv-config {						\
		hvlv-dly = <0x01>;					\
		hvlv-thld-hys = <0x00>;					\
		hvlv-thld = <0x08>;					\
	};								\
									\
	cirrus,ldpm-config {						\
		ldpm-gp2-pcm-thld = <0x06>;				\
		ldpm-gp2-delay = <0x06>;				\
		ldpm-gp2-vmon-sel = <0x01>;				\
		ldpm-gp2-imon-sel = <0x01>;				\
		ldpm-gp1-pcm-thld = <0x06>;				\
		ldpm-gp1-delay = <0x06>;				\
		ldpm-gp1-amp-sel = <0x01>;				\
		ldpm-gp1-boost-sel = <0x01>;				\
	};								\
									\
	/*								\
	 * ch-hdrm is INTENTIONALLY ABSENT. The vendor driver looks it	\
	 * up in classh_map[], but this device's own stock device tree	\
	 * does not declare it, so stock leaves CH_HDRM at its power-on	\
	 * value -- and so must we. Do not "complete" this node by	\
	 * adding it: that is a deviation from the reference device,	\
	 * not a fix.							\
	 */								\
	cirrus,classh-config {						\
		ch-thld1-offset = <0x2d>;				\
		ch-ovb-ratio = <0x01>;					\
		ch-vdd-bst-max = <0xfa>;				\
		ch-ovb-thlddelta = <0x28>;				\
		ch-ovb-thld1 = <0x82>;					\
		ch-rel-rate = <0x04>;					\
		ch-ratio = <0x05>;					\
	};

/*
 * Noise gate. Stock declares a threshold and a hold for both mixer channels,
 * identically on all four amplifiers, and the vendor driver reads all four
 * under exactly these names.
 *
 * 🔴 THE GATE IS NOT ENABLED BY THESE PROPERTIES, AND MUST NOT BE. The enable
 * is bit 16 of the same register and is driven from a DAPM switch, which stock
 * leaves OFF on all four amplifiers in idle and during playback alike. These
 * four numbers only tune a block that neither system switches on. Adding an
 * enable control here, or the DAPM widgets and routes that would carry one,
 * would be a deviation from the reference device rather than a completion of
 * this block.
 *
 * Unlike the blocks above, these are properties on the amplifier node itself,
 * not a child node, which is why they carry the "cirrus," prefix.
 */
#define CS35L45_GTS9U_NOISE_GATE_CONFIG				\
	cirrus,ngate-ch1-hold = <0x02>;					\
	cirrus,ngate-ch1-thr = <0x06>;					\
	cirrus,ngate-ch2-hold = <0x02>;					\
	cirrus,ngate-ch2-thr = <0x06>;

#include <dt-bindings/sound/qcom,q6dsp-lpass-ports.h>
#include <dt-bindings/usb/pd.h>
#include "sm8550.dtsi"
#include "pm8550.dtsi"
#include "pm8550vs.dtsi"
#include "pmk8550.dtsi"

/*
 * Reserved-memory carveout edit-set — evidence-grounded, NOT a q5q clone.
 * 3-way bidirectional carveout check: pristine v7.0
 * sm8550.dtsi already matches the live gts9u SoC map byte-for-byte
 * except two SIZE-DIFF regions; gts9u-specific deltas only below.
 *
 *   adspslpi_mem : mainline +0x4080000 -> gts9u +0x59b4000  (SIZE-DIFF)
 *   hwfence_shbuf: mainline +0x279000  -> gts9u +0x2dd000   (SIZE-DIFF)
 *   rmtfs_mem    : DELETED  (gts9uwifi = WiFi-only; live map has no
 *                  rmtfs region — bidirectional-consistent)
 *   trust_ui_vm_*: mainline @f3600000.. -> gts9u @f3800000.. (re-addr)
 *   mpss_mem     : KEPT mainline (@8a800000 +0x10800000 == live; q5q's
 *                  @8b400000 is the OUTDATED Z-Fold5 override — NOT used)
 */
/delete-node/ &adspslpi_mem;
/delete-node/ &hwfence_shbuf;
/delete-node/ &rmtfs_mem;
/delete-node/ &trust_ui_vm_mem;
/delete-node/ &trust_ui_vm_dump;
/delete-node/ &trust_ui_vm_qrtr;
/delete-node/ &trust_ui_vm_vblk0_ring;
/delete-node/ &trust_ui_vm_vblk1_ring;
/delete-node/ &trust_ui_vm_swiotlb;

/ {
	model = "Samsung Galaxy Tab S9 Ultra";
	compatible = "samsung,gts9u", "qcom,sm8550";
	chassis-type = "tablet";

	/*
	 * Root qcom,msm-id / qcom,board-id mirror the live stock gts9u
	 * r03 DTB (overlay1.dts board-id 0x10008,0x03). Decision B.1
	 * a Samsung-format mainline DTB BY DEFINITION
	 * carries these; including them makes Step-2's first flash the
	 * implicit test of the precise-scope-banner's untested
	 * ABL-overlay-onto-Samsung-format-DTB case. Harmless to the
	 * mainline kernel (unknown root props ignored); only changes
	 * Samsung ABL LocalBoardDtMatch-on-base behaviour.
	 */
	qcom,msm-id = <0x218 0x20000 0x207 0x20000 0x207 0x10000 0x218 0x10000>;
	qcom,board-id = <0x10008 0x03>;

	aliases {
		/*
		 * A "serial" alias is REQUIRED for every enabled GENI UART:
		 * qcom_geni_serial assigns the port line via
		 * of_alias_get_id(node, "serial") and FAILS probe ("Invalid line
		 * -19" = -ENODEV) without one. The numbering mirrors the in-tree
		 * sm8550-qrd.dts reference, which carries these same two entries.
		 *
		 * uart14 is the Bluetooth serdev engine (see the &uart14 block
		 * below). The alias ONLY numbers its port; it does NOT make it a
		 * console — there is no stdout-path here and the cmdline carries no
		 * console=ttyMSM0, so no console is registered on it (and the
		 * bluetooth serdev child claims the port). Console is tty0 (panel)
		 * + the USB CDC-ACM gadget (ttyGS0). uart7 stays disabled; its
		 * alias is kept so that enabling it later as a debug console does
		 * not renumber uart14.
		 */
		serial0 = &uart7;
		serial1 = &uart14;

		/*
		 * Pin the SM5714 charger/PDIC i2c-hub bus numbers, and place the
		 * SM5440 charge-pump bus at a fixed i2c-2. Without these, i2c bus
		 * ids are dynamic (assigned in probe order): enabling &i2c_hub_3
		 * (i2c@98c000, the SM5440 bus) below would perturb the numbering and
		 * could move the SM5714 charger off bus 0, breaking every tool that
		 * addresses it there. of_alias_get_highest_id() raises the dynamic
		 * base above the highest i2c alias, so these pins are race-free; the
		 * unrelated regular-QUP buses (currently i2c-2/i2c-3 = touch/sensors,
		 * DT-bound with no bus-number dependency) float up accordingly.
		 */
		i2c0 = &i2c_hub_8;	/* SM5714 charger 0x49 / MUIC 0x25 / FG 0x71 */
		i2c1 = &i2c_hub_9;	/* SM5714 PDIC 0x33 */
		i2c2 = &i2c_hub_3;	/* SM5440 charge-pump 0x63 (rung-3 45 W) */
		i2c3 = &i2c_hub_6;	/* CS35L45 speaker amps 0x30-0x33 */
	};

	chosen {
		#address-cells = <2>;
		#size-cells = <2>;
		ranges;

		/*
		 * gts9u panel = GTS9U_ANA38407_AMSA46AS02 (live bootargs);
		 * SM-X910 native 2960x1848. splash_region@b8000000 is the
		 * ABL cont_splash buffer (same base as q5q; live carveout
		 * map MAP). Observability, not ~6 s-critical.
		 */
		framebuffer: framebuffer@b8000000 {
			compatible = "simple-framebuffer";
			reg = <0x0 0xb8000000 0x0 0x2b00000>;
			width = <2960>;
			height = <1848>;
			stride = <(2960 * 4)>;
			format = "a8r8g8b8";
			/*
			 * Disabled: enabling this node (so simplefb binds and drives
			 * the panel) was tested and did NOT keep the panel alive --
			 * the bootloader powers the panel down ("Splash region not
			 * found in device tree") before the kernel jump regardless of
			 * this node. Kept disabled so no simplefb probe runs during
			 * boot (baseline; isolates simplefb as a boot-time variable).
			 */
			status = "disabled";
		};
	};

	gpio-keys {
		compatible = "gpio-keys";
		pinctrl-0 = <&volume_up_n>, <&hall_cover_n>;
		pinctrl-names = "default";

		key-volume-up {
			label = "Volume Up";
			linux,code = <KEY_VOLUMEUP>;
			gpios = <&pm8550_gpios 6 GPIO_ACTIVE_LOW>;
			debounce-interval = <15>;
			linux,can-disable;
			wakeup-source;
		};

		/*
		 * Book-cover magnetic hall sensor. Every value here is this
		 * device's OWN, read out of its downstream DTS hall_ic node:
		 * hall { gpios = <&tlmm 0x6b 0x01>; } is TLMM 107 ACTIVE_LOW,
		 * and hall_ic,debounce-interval = <0x32> is 50 ms.
		 *
		 * POLARITY, derived from the downstream driver rather than
		 * assumed. hall_ic.c sets active_low from the DT flag, then
		 * reports `state ^ active_low` and logs it as "close"/"open" --
		 * so a CLOSED cover drives the pin physically LOW. gpio-keys
		 * with GPIO_ACTIVE_LOW turns that into logical 1, and
		 * linux-event-codes.h defines SW_LID as "set = lid shut". The
		 * three agree, so closing the cover reports SW_LID=1.
		 *
		 * 🔴 WE DELIBERATELY EMIT SW_LID, WHICH IS **NOT** WHAT STOCK
		 * EMITS. Samsung's own code for this sensor is SW_FLIP (0x15),
		 * which exceeds upstream's SW_MAX, so hall_ic_parsing_dt()
		 * remaps it onto SW_MACHINE_COVER (0x10) before registering the
		 * input device. Nothing in our userspace consumes 0x10 --
		 * logind's HandleLidSwitch listens for SW_LID and nothing else.
		 * Matching stock's BEHAVIOUR here means diverging from its
		 * literal event number. (User-directed; supersedes ADR-0023
		 * DEC-135, which said a cover close should not suspend.)
		 *
		 * wakeup-source mirrors stock, whose hall_ic_suspend() calls
		 * enable_irq_wake() on every hall so an open can wake the
		 * device. gpio-keys also re-reports switch state on resume,
		 * which stock open-codes in hall_ic_resume() because the GPIO
		 * can change while frozen with no interrupt delivered.
		 */
		switch-cover {
			label = "Book Cover";
			linux,input-type = <EV_SW>;
			linux,code = <SW_LID>;
			gpios = <&tlmm 107 GPIO_ACTIVE_LOW>;
			debounce-interval = <50>;
			linux,can-disable;
			wakeup-source;
		};
	};

	vph_pwr: vph-pwr-regulator {
		compatible = "regulator-fixed";
		regulator-name = "vph_pwr";
		regulator-min-microvolt = <3700000>;
		regulator-max-microvolt = <3700000>;
		regulator-always-on;
		regulator-boot-on;
	};

	/*
	 * panel_ldo_en — overlay1.dts fixed_regulator@0:
	 * gpio <0xffffffff 0xbb 0x00> = &tlmm 187 active-high,
	 * regulator-boot-on. Display-related; not ~6 s-critical.
	 */
	panel_ldo_en: panel-ldo-en-regulator {
		compatible = "regulator-fixed";
		regulator-name = "panel_ldo_en";
		gpio = <&tlmm 187 GPIO_ACTIVE_HIGH>;
		enable-active-high;
		regulator-boot-on;
	};

	/*
	 * vreg_spkr_amp — the supply rail behind all four CS35L45 speaker
	 * amplifiers. The device's own stock dtbo (gts9uwifi r03,
	 * fragment@159) carries this as a regulator-fixed named "dummy_vreg",
	 * with every amp's VP-supply AND VA-supply pointing at it.
	 *
	 * The stock name is misleading and is deliberately not reproduced: the
	 * node is not a placeholder, it gates a real rail on TLMM 19
	 * (gpio = <0xffffffff 0x13 0x00> in the overlay, resolved to &tlmm via
	 * its own __fixups__), and TLMM 19 has exactly one consumer in the whole
	 * stock overlay — this node. regulator-always-on because stock drives it
	 * high at boot and never releases it; the amps have no other supply.
	 *
	 * Mainline's cs35l45 driver requests "vdd-a" and "vdd-batt"
	 * (cs35l45.c:1379,1384), NOT stock's VP/VA property names. Because
	 * regulator_get() substitutes a dummy regulator on a DT system rather
	 * than failing, a mis-named supply would probe clean and silently leave
	 * this GPIO undriven — so the rename is load-bearing, not cosmetic.
	 */
	vreg_spkr_amp: spkr-amp-regulator {
		compatible = "regulator-fixed";
		regulator-name = "vreg_spkr_amp";
		gpio = <&tlmm 19 GPIO_ACTIVE_HIGH>;
		enable-active-high;
		regulator-always-on;
		regulator-boot-on;
	};

	/*
	 * stm32_vddo — I/O rail for the Book Cover Keyboard's STM32 MCU
	 * (R12 keyboard cover). Device-own value (gts9uwifi r03 fixed_regulator@1):
	 * a GPIO-enabled fixed regulator on TLMM 10, active-high. The stm32_pogo_v3
	 * driver enables this rail (stm32_dev_regulator) when the cover attaches,
	 * before talking to the MCU over i2c15. NOT regulator-boot-on: the driver
	 * owns the on/off so power tracks cover attach/detach.
	 */
	kbd_stm32_vddo: kbd-stm32-vddo-regulator {
		compatible = "regulator-fixed";
		regulator-name = "kbd_stm32_vddo";
		gpio = <&tlmm 10 GPIO_ACTIVE_HIGH>;
		enable-active-high;
		pinctrl-names = "default";
		pinctrl-0 = <&kbd_ldo_en>;
	};

	/*
	 * Book Cover Keyboard keypad logical device. The stm32_pogo_v3 core
	 * (keyboard@2a on i2c15) owns the I2C link and, on cover attach,
	 * broadcasts key data over a kernel notifier chain. The keypad input
	 * device is registered by a SEPARATE platform driver (name "stm32_kpd",
	 * compatible "stm,keypad") that subscribes to that chain. of_platform
	 * instantiates this root node into the platform device the driver binds
	 * to; without it the keypad driver's platform_driver_probe() finds no
	 * device and no input device is ever created. Authored from the device's
	 * own downstream source (gts9uwifi r03, fragment@72 pogo_kpd) for the
	 * names + supported-model list.
	 *
	 * The supported covers (EF-DX9xx, model ids below) are all "bypass"
	 * models: the MCU does the matrix scan and emits final keycodes, so the
	 * host keymap is never consulted (see _bypass.c). The num-rows/columns +
	 * linux,keymap1/2 below are a PARSE-SAFETY STUB only: stm32_parse_dt()
	 * reads them unconditionally at probe and dereferences a NULL keymap
	 * pointer / uses an uninitialised length if they are absent. The values
	 * are inert for bypass covers.
	 */
	pogo_kpd: pogo-keypad {
		compatible = "stm,keypad";
		keypad,input_name = "Book Cover Keyboard (EF-DX915)",
			"Book Cover Keyboard Slim (EF-DX910)",
			"Book Cover Keyboard (EF-DX900)",
			"Book Cover Keyboard (EF-DX925)",
			"Book Cover Keyboard Slim (EF-DX920)",
			"Neos Keyboard";
		keypad,input_name_row = [00];
		keypad,support_keyboard_model = <0xf9 0xf8 0xfe 0xd3 0xd6 0x51>;
		keypad,num-rows = <1>;
		keypad,num-columns = <1>;
		linux,keymap1 = <0x00000002>;
		linux,keymap2 = <0x00000002>;
	};

	/*
	 * QCA WCN7850 (Samsung codename "kiwi"; PCI 17cb:1107) Wi-Fi/BT
	 * power-management unit. Bound by pwrseq-qcom-wcn (the power-
	 * sequencing provider): it enables the six SoC-rail inputs, toggles
	 * the WLAN/BT enable GPIOs in the required order, and exposes ten
	 * LDO outputs (vreg_pmu_*) that the wifi@0 (and, later, the BT)
	 * consumer references as its supplies. PCI_PWRCTRL_PWRSEQ runs this
	 * sequence before the PCIe endpoint is enumerated.
	 *
	 * Structure copied from the in-tree sm8550-qrd.dts WCN7850 reference
	 * (the canonical mainline board for this binding). Device-own values:
	 *   - wlan-enable-gpios = TLMM 80, bt-enable-gpios = TLMM 81: extracted
	 *     from this device's stock bt_kiwi node (qcom,wl-reset-gpio = 0x50,
	 *     qcom,bt-reset-gpio = 0x51) -- identical to the QRD layout.
	 *   - The six input supplies are remapped from the QRD's rail names to
	 *     this device's RPMh rail labels (same SMPS/LDO identity, ranges
	 *     cover the WCN requirements): s5g, l15b, s2g, s4e, s4g, s6g.
	 * The regulators{} subtree (the WCN chip's own LDO outputs) is chip-
	 * intrinsic and copied verbatim. The 32 kHz reference is delivered via
	 * the pmk8550_sleep_clk pin (see &pmk8550_gpios), not a clocks= phandle.
	 */
	wcn7850-pmu {
		compatible = "qcom,wcn7850-pmu";

		pinctrl-names = "default";
		pinctrl-0 = <&wlan_en>, <&bt_default>, <&pmk8550_sleep_clk>;

		wlan-enable-gpios = <&tlmm 80 GPIO_ACTIVE_HIGH>;
		bt-enable-gpios = <&tlmm 81 GPIO_ACTIVE_HIGH>;

		vdd-supply = <&vreg_s5g_0p8>;
		vddio-supply = <&vreg_l15b_1p8>;
		vddaon-supply = <&vreg_s2g_0p8>;
		vdddig-supply = <&vreg_s4e_0p9>;
		vddrfa1p2-supply = <&vreg_s4g_1p3>;
		vddrfa1p8-supply = <&vreg_s6g_1p8>;

		regulators {
			vreg_pmu_rfa_cmn: ldo0 {
				regulator-name = "vreg_pmu_rfa_cmn";
			};

			vreg_pmu_aon_0p59: ldo1 {
				regulator-name = "vreg_pmu_aon_0p59";
			};

			vreg_pmu_wlcx_0p8: ldo2 {
				regulator-name = "vreg_pmu_wlcx_0p8";
			};

			vreg_pmu_wlmx_0p85: ldo3 {
				regulator-name = "vreg_pmu_wlmx_0p85";
			};

			vreg_pmu_btcmx_0p85: ldo4 {
				regulator-name = "vreg_pmu_btcmx_0p85";
			};

			vreg_pmu_rfa_0p8: ldo5 {
				regulator-name = "vreg_pmu_rfa_0p8";
			};

			vreg_pmu_rfa_1p2: ldo6 {
				regulator-name = "vreg_pmu_rfa_1p2";
			};

			vreg_pmu_rfa_1p8: ldo7 {
				regulator-name = "vreg_pmu_rfa_1p8";
			};

			vreg_pmu_pcie_0p9: ldo8 {
				regulator-name = "vreg_pmu_pcie_0p9";
			};

			vreg_pmu_pcie_1p8: ldo9 {
				regulator-name = "vreg_pmu_pcie_1p8";
			};
		};
	};

	reserved-memory {
		#address-cells = <2>;
		#size-cells = <2>;
		ranges;

		/* SIZE-DIFF redeclares (gts9u live values) */
		adspslpi_mem: adspslpi@9ea00000 {
			reg = <0x0 0x9ea00000 0x0 0x59b4000>;
			no-map;
		};

		hwfence_shbuf: hwfence-shbuf-region@e6440000 {
			reg = <0x0 0xe6440000 0x0 0x2dd000>;
			no-map;
		};

		/* trust_ui_vm_* redeclared at gts9u live addresses */
		trust_ui_vm_mem: trust-ui-vm-region@f3800000 {
			reg = <0x0 0xf3800000 0x0 0x40ee000>;
			no-map;
		};

		trust_ui_vm_dump: trust-ui-vm-dump-region@f78ee000 {
			reg = <0x0 0xf78ee000 0x0 0x1000>;
			no-map;
		};

		trust_ui_vm_qrtr: trust-ui-vm-qrtr-region@f78ef000 {
			reg = <0x0 0xf78ef000 0x0 0x9000>;
			no-map;
		};

		trust_ui_vm_vblk0_ring: trust-ui-vm-vblk0-ring-region@f78f8000 {
			reg = <0x0 0xf78f8000 0x0 0x4000>;
			no-map;
		};

		trust_ui_vm_vblk1_ring: trust-ui-vm-vblk1-ring-region@f78fc000 {
			reg = <0x0 0xf78fc000 0x0 0x4000>;
			no-map;
		};

		trust_ui_vm_swiotlb: trust-ui-vm-swiotlb-region@f7900000 {
			reg = <0x0 0xf7900000 0x0 0x100000>;
			no-map;
		};

		/*
		 * ADD set — gts9u XBL/TZ locks these; pristine v7.0
		 * sm8550.dtsi does NOT reserve them. THE ~6 s-killer
		 * direction (cause-4): a region XBL locked that the DT
		 * does not mark reserved -> kernel allocates -> secure
		 * violation -> ~6 s fast-fatal.
		 */
		chipinfo_mem: chipinfo-region@81cf4000 {
			reg = <0x0 0x81cf4000 0x0 0x1000>;
			no-map;
		};

		sec_xbl_ramdump_mem: sec-xbl-ramdump-region@a7d00000 {
			reg = <0x0 0xa7d00000 0x0 0x300000>;
			no-map;
		};

		kaslr_mem: kaslr-region@b01ff000 {
			reg = <0x0 0xb01ff000 0x0 0x1000>;
			no-map;
		};

		/*
		 * The bootloader keeps display hardware enabled only if this
		 * region exists; named 'splash_region' (matches the live stock
		 * resolved DT). MAP: the stock DT carves it MAP. Making it no-map
		 * (q5q-style) was tested and did NOT keep the panel alive, so it
		 * is reverted to the stock MAP carveout (baseline).
		 */
		splash_region: splash-region@b8000000 {
			reg = <0x0 0xb8000000 0x0 0x2b00000>;
		};

		llcc_lpi_mem: llcc-lpi-region@ff800000 {
			reg = <0x0 0xff800000 0x0 0x600000>;
			no-map;
		};

		/* High extended-DDR Samsung debug/boot set (live map) */
		sec_debug_region_pool: sec-debug-region-pool@880100000 {
			reg = <0x8 0x80100000 0x0 0xff000>;
		};

		sec_rst_ex_info_mem: sec-rst-ex-info-region@8801ff000 {
			reg = <0x8 0x801ff000 0x0 0x1000>;
			no-map;
		};

		sec_log_buf_region: sec-log-buf-region@880200000 {
			reg = <0x8 0x80200000 0x0 0x200000>;
		};

		sec_debug_bl_mem: sec-debug-bl-region@880400000 {
			reg = <0x8 0x80400000 0x0 0x500000>;
			no-map;
		};

		sec_pmsg_region: sec-pmsg-region@880900000 {
			reg = <0x8 0x80900000 0x0 0x200000>;
		};

		google_debug_kinfo_mem: google-debug-kinfo-region@880b00000 {
			reg = <0x8 0x80b00000 0x0 0x1000>;
			no-map;
		};

		hdm_mem: hdm-region@880b01000 {
			reg = <0x8 0x80b01000 0x0 0x1000>;
			no-map;
		};

		/*
		 * ramoops console capture: carveout-free gap (hdm-region end
		 * 0x8_80b02000 .. rdx-bootdev 0x8_80c00000), inside the
		 * ABL-declared high-DDR bank (0x8_80000000 + 0x37800000). Sizes
		 * match the downstream reader's pstore-ram zone layout so the
		 * same region is read back after a warm reboot.
		 */
		ramoops@880b10000 {
			compatible = "ramoops";
			reg = <0x8 0x80b10000 0x0 0xc0000>;
			no-map;
			console-size = <0x40000>;
			record-size = <0x20000>;
			ftrace-size = <0x20000>;
			pmsg-size = <0x0>;
			ecc-size = <0x10>;
			max-reason = <0x05>;
		};

		sec_qcom_rdx_bootdev_region: sec-qcom-rdx-bootdev-region@880c00000 {
			reg = <0x8 0x80c00000 0x0 0xad00000>;
		};
	};

	/*
	 * The pack fitted to this device, referenced by the fuel gauge through
	 * monitored-battery.
	 *
	 * WHY THIS NODE EXISTS. Without a design capacity the fuel gauge can
	 * publish CAPACITY (percent) but not CHARGE_FULL_DESIGN / CHARGE_FULL /
	 * CHARGE_NOW. upower derives BOTH its health figure
	 * (energy-full / energy-full-design) and its time-to-empty estimate
	 * (energy / energy-rate) from those, so with them absent it reports
	 * "energy-full-design: 0 Wh", a Battery Health of 0 %, and a Remaining
	 * Time stuck on "Estimating..." forever. Percentage and charge rate
	 * worked all along, which is precisely what made this look like a
	 * desktop bug rather than a missing kernel property.
	 *
	 * 🔴 BOTH VALUES ARE THIS DEVICE'S OWN, transcribed from its downstream
	 * device tree -- not a datasheet, not marketing, not a sister device:
	 *
	 *   gts9uwifi_eur_open_w00_r03.dts:227
	 *       battery,battery_full_capacity = <0x2648>;   // 9800 mAh
	 *   gts9uwifi_eur_open_w00_r03.dts:179
	 *       battery,chg_float_voltage    = <0x1158>;    // 4440 mV
	 *
	 * sec_battery.c:6367-6369 returns battery_full_capacity * 1000 (uAh) for
	 * CHARGE_FULL_DESIGN. The widely quoted 11200 mAh is marketing and
	 * appears NOWHERE in the vendor tree -- do not "correct" this to it.
	 *
	 * voltage-min-design-microvolt is deliberately ABSENT: this pack uses
	 * hardware empty detection (fuelgauge,using_hw_vempty in the same file)
	 * and the vendor tree carries no design-minimum in millivolts. Inventing
	 * one would put a fabricated number where a measured one belongs.
	 */
	battery: battery {
		compatible = "simple-battery";
		charge-full-design-microamp-hours = <9800000>;
		voltage-max-design-microvolt = <4440000>;
	};

	/*
	 * Speaker sound card.
	 *
	 * The four CS35L45 amplifiers hang off the LPASS primary serial audio
	 * interface, driven as a 4-slot TDM frame -- which is what stock does,
	 * and what lets each amplifier own a slot rather than two of them
	 * sharing a channel.
	 *
	 * The frame is stock's, value for value:
	 *   4 slots          qcom,tdm-max-slots = <4>, this device's own dtbo
	 *   32-bit slots     TDM_SLOT_WIDTH_BITS, and the downstream machine
	 *                    driver's snd_soc_dai_set_tdm_slot(codec, 0, 0, 0, 32)
	 *   24-bit samples   PAL_AUDIO_FMT_PCM_S24_LE for PAL_DEVICE_OUT_SPEAKER
	 *   48 kHz           same
	 *   DSP_A, codec-consumer, inverted bit clock
	 *                    the downstream LPASS_BE_PRI_TDM_RX_0 link's .dai_fmt
	 * giving a 6.144 MHz bit clock (48000 x 32 x 4).
	 *
	 * The slot width is 32 while the samples are 24-bit: a 24-bit sample
	 * rides inside a 32-bit slot, and it is the SLOT width that sets the bit
	 * clock. Deriving the slot width from the sample width instead would ask
	 * for 4.608 MHz, and look entirely reasonable doing it.
	 *
	 * Which amplifier takes which slot is NOT set here. A CS35L45 does not
	 * learn its slot from the DAI -- it has its own ASPRX Slot Position
	 * controls, driven from userspace, and stock uses exactly those:
	 * front-left 0, front-right 1, rear-left 2, rear-right 3.
	 *
	 * model= is load-bearing, not cosmetic: audioreach_tplg_init()
	 * (qdsp6/topology.c:1318) builds the topology firmware path as
	 *     "qcom/<card->driver_name>/<card->name>-tplg.bin"
	 * where driver_name is the sndcard match data ("sm8550" for
	 * qcom,sm8550-sndcard, sc8280xp.c:176) and card->name is this model
	 * string (common.c:38). So this node asks for
	 *     /lib/firmware/qcom/sm8550/GTS9U-tplg.bin
	 * and without that file the card still probes -- request_firmware simply
	 * fails and the graph is empty.
	 *
	 * That topology has to name this interface in three more places than the
	 * endpoint module: the graph index IS the DAI id (24 here), and the
	 * stream and mixer widget names must match the ones q6dsp-lpass-ports.c
	 * builds for PRIMARY_TDM_RX_0. A topology that changes only the module
	 * loads happily and routes nothing.
	 *
	 * The format is NOT set here: sc8280xp_snd_init() matches
	 * PRIMARY_TDM_RX_0 and applies DSP_A / codec-consumer / inverted bit
	 * clock to the CPU and the four codec DAIs together, along with the
	 * 4 x 32-bit slot layout. Stock agrees the SoC drives the clocks
	 * (qcom,msm-mi2s-master = <1 1 1 1 1 1> in its own sound node).
	 */
	sound {
		compatible = "qcom,sm8550-sndcard";
		model = "GTS9U";

		/*
		 * Microphone bias. The VA macro exposes its vdd-micb-supply as
		 * a DAPM regulator-supply widget literally named "vdd-micb"
		 * (lpass-va-macro.c: SND_SOC_DAPM_REGULATOR_SUPPLY), and that
		 * widget is powered only by a route reaching it -- nothing
		 * inside the macro connects it. Boards with no WCD codec spell
		 * it exactly this way (qcs6490-rb3gen2, qrb5165-rb5,
		 * x1e80100-lenovo-yoga-slim7x); this device has no WCD either
		 * (stock's own sound node sets qcom,wcd-disabled = <1>), so
		 * there is no "MIC BIASn" to borrow.
		 *
		 * The three entries mirror stock's own routing, which ties
		 * Digital Mic0-5 to "VA MIC BIAS". Only the odd indices are
		 * populated on this SKU -- see the DMIC MUX note below.
		 */
		audio-routing = "VA DMIC1", "vdd-micb",
				"VA DMIC3", "vdd-micb",
				"VA DMIC5", "vdd-micb";

		pinctrl-names = "default", "sleep";
		pinctrl-0 = <&mi2s0_active>;
		pinctrl-1 = <&mi2s0_sleep>;

		speaker-dai-link {
			link-name = "Speaker Playback";

			cpu {
				sound-dai = <&q6apmbedai PRIMARY_TDM_RX_0>;
			};

			codec {
				sound-dai = <&spkr_amp_rl 0>, <&spkr_amp_fl 0>,
					    <&spkr_amp_rr 0>, <&spkr_amp_fr 0>;
			};

			platform {
				sound-dai = <&q6apm>;
			};
		};

		/*
		 * Digital microphones.
		 *
		 * VA_CODEC_DMA_TX_0 rather than TX_CODEC_DMA_TX_3: both are
		 * carried by q6apm-lpass-dais.c, but the VA port is the one
		 * paired with <&vamacro 0> on boards that have no WCD codec to
		 * share the TX port with (sc8280xp-lenovo-thinkpad-x13s,
		 * qcs6490-rb3gen2, x1e80100-lenovo-yoga-slim7x). sm8450-hdk
		 * uses TX_CODEC_DMA_TX_3 for its VA link, but it does so
		 * alongside a WCD938x on the same port; we have neither.
		 */
		mic-dai-link {
			link-name = "DMIC Capture";

			cpu {
				sound-dai = <&q6apmbedai VA_CODEC_DMA_TX_0>;
			};

			codec {
				sound-dai = <&lpass_vamacro 0>;
			};

			platform {
				sound-dai = <&q6apm>;
			};
		};
	};
};

/*
 * RPMh regulators — pm8550 family (b/c/d/e/f/g/m/n). gts9u uses the
 * same PMIC family as q5q (overlay1 confirms pm8550/pm8550vs/pmk8550);
 * the RPMh rail topology is PMIC-family-determined. q5q is the proven
 * Samsung-SM8550 instance — first-cut pattern (per-rail
 * microvolt refinement vs overlay1 is a banked follow-up, NOT
 * ~6 s-critical: the death is pre-userspace).
 */
&apps_rsc {
	regulators-0 {
		compatible = "qcom,pm8550-rpmh-regulators";
		qcom,pmic-id = "b";

		vreg_l1b_1p8: ldo1 {
			regulator-name = "vreg_l1b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2b_3p0: ldo2 {
			regulator-name = "vreg_l2b_3p0";
			regulator-min-microvolt = <3008000>;
			regulator-max-microvolt = <3008000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l5b_3p1: ldo5 {
			regulator-name = "vreg_l5b_3p1";
			regulator-min-microvolt = <3104000>;
			regulator-max-microvolt = <3104000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
			/* PTN3222 eUSB2 repeater vdd3v3: kept on with no driver
			 * consumer (the repeater is brought up in hardware --
			 * see the USB section). */
			regulator-always-on;
		};

		vreg_l6b_1p8: ldo6 {
			regulator-name = "vreg_l6b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <3008000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l7b_1p8: ldo7 {
			regulator-name = "vreg_l7b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <3008000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l8b_1p8: ldo8 {
			regulator-name = "vreg_l8b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <3008000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l9b_2p9: ldo9 {
			regulator-name = "vreg_l9b_2p9";
			regulator-min-microvolt = <2960000>;
			regulator-max-microvolt = <3008000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		/*
		 * Digital-microphone bias. This device's own stock base tree
		 * defines the rail as pm_humu_l10 / L10B on rpmh resource
		 * "ldob10" with min = max = init = 1800000 uV, and its stock
		 * dtbo names L10B as the va-macro's va-vdd-micb-supply. The VA
		 * macro's own node agrees: qcom,va-vdd-micb-voltage =
		 * <1800000 1800000>, qcom,va-vdd-micb-current = <1500>.
		 */
		vreg_l10b_1p8: ldo10 {
			regulator-name = "vreg_l10b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l11b_1p2: ldo11 {
			regulator-name = "vreg_l11b_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1504000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		/*
		 * Candidate panel VDDIO (1.8V) / VCI (3.0V) rails. The panel
		 * node is wired to panel_ldo_en (the only rail the downstream
		 * device tree software-controls for the panel); these two are
		 * kept always-on as a DEFENSIVE GUESS for the panel's I/O /
		 * analog rails, pending schematic confirmation. Drop the
		 * always-on flags one at a time after first light to identify
		 * which (if any) is actually load-bearing.
		 */
		vreg_l12b_1p8: ldo12 {
			regulator-name = "vreg_l12b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
			regulator-always-on;
		};

		vreg_l13b_3p0: ldo13 {
			regulator-name = "vreg_l13b_3p0";
			regulator-min-microvolt = <3000000>;
			regulator-max-microvolt = <3000000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
			regulator-always-on;
		};

		vreg_l14b_3p2: ldo14 {
			regulator-name = "vreg_l14b_3p2";
			regulator-min-microvolt = <3200000>;
			regulator-max-microvolt = <3200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l15b_1p8: ldo15 {
			regulator-name = "vreg_l15b_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
			regulator-allow-set-load;
			regulator-allowed-modes = <RPMH_REGULATOR_MODE_LPM
						   RPMH_REGULATOR_MODE_HPM>;
			regulator-always-on;
		};

		vreg_l16b_2p8: ldo16 {
			regulator-name = "vreg_l16b_2p8";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <2800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l17b_2p5: ldo17 {
			regulator-name = "vreg_l17b_2p5";
			regulator-min-microvolt = <2504000>;
			regulator-max-microvolt = <2504000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-1 {
		compatible = "qcom,pm8550vs-rpmh-regulators";
		qcom,pmic-id = "c";

		vreg_l3c_0p91: ldo3 {
			regulator-name = "vreg_l3c_0p9";
			regulator-min-microvolt = <880000>;
			regulator-max-microvolt = <912000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-2 {
		compatible = "qcom,pm8550vs-rpmh-regulators";
		qcom,pmic-id = "d";

		vreg_l1d_0p88: ldo1 {
			regulator-name = "vreg_l1d_0p88";
			regulator-min-microvolt = <880000>;
			regulator-max-microvolt = <920000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-3 {
		compatible = "qcom,pm8550vs-rpmh-regulators";
		qcom,pmic-id = "e";

		vreg_s4e_0p9: smps4 {
			regulator-name = "vreg_s4e_0p9";
			regulator-min-microvolt = <904000>;
			regulator-max-microvolt = <984000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s5e_1p1: smps5 {
			regulator-name = "vreg_s5e_1p1";
			regulator-min-microvolt = <1080000>;
			regulator-max-microvolt = <1120000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l1e_0p88: ldo1 {
			regulator-name = "vreg_l1e_0p88";
			regulator-min-microvolt = <880000>;
			regulator-max-microvolt = <880000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2e_0p9: ldo2 {
			regulator-name = "vreg_l2e_0p9";
			regulator-min-microvolt = <904000>;
			regulator-max-microvolt = <970000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l3e_1p2: ldo3 {
			regulator-name = "vreg_l3e_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-4 {
		compatible = "qcom,pm8550ve-rpmh-regulators";
		qcom,pmic-id = "f";

		vreg_s4f_0p5: smps4 {
			regulator-name = "vreg_s4f_0p5";
			regulator-min-microvolt = <500000>;
			regulator-max-microvolt = <700000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l1f_0p9: ldo1 {
			regulator-name = "vreg_l1f_0p9";
			regulator-min-microvolt = <912000>;
			regulator-max-microvolt = <912000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2f_0p88: ldo2 {
			regulator-name = "vreg_l2f_0p88";
			regulator-min-microvolt = <880000>;
			regulator-max-microvolt = <912000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l3f_0p91: ldo3 {
			regulator-name = "vreg_l3f_0p91";
			regulator-min-microvolt = <880000>;
			regulator-max-microvolt = <912000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-5 {
		compatible = "qcom,pm8550vs-rpmh-regulators";
		qcom,pmic-id = "g";

		vreg_s1g_1p2: smps1 {
			regulator-name = "vreg_s1g_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1300000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s2g_0p8: smps2 {
			regulator-name = "vreg_s2g_0p8";
			regulator-min-microvolt = <800000>;
			regulator-max-microvolt = <1000000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s3g_0p7: smps3 {
			regulator-name = "vreg_s3g_0p7";
			regulator-min-microvolt = <300000>;
			regulator-max-microvolt = <1004000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s4g_1p3: smps4 {
			regulator-name = "vreg_s4g_1p3";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1352000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s5g_0p8: smps5 {
			regulator-name = "vreg_s5g_0p8";
			regulator-min-microvolt = <500000>;
			regulator-max-microvolt = <1004000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_s6g_1p8: smps6 {
			regulator-name = "vreg_s6g_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <2000000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l1g_1p2: ldo1 {
			regulator-name = "vreg_l1g_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2g_1p2: ldo2 {
			regulator-name = "vreg_l2g_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l3g_1p2: ldo3 {
			regulator-name = "vreg_l3g_1p2";
			regulator-min-microvolt = <1200000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-6 {
		compatible = "qcom,pm8010-rpmh-regulators";
		qcom,pmic-id = "m";

		vreg_l1m_1p056: ldo1 {
			regulator-name = "vreg_l1m_1p056";
			regulator-min-microvolt = <1056000>;
			regulator-max-microvolt = <1056000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2m_1p056: ldo2 {
			regulator-name = "vreg_l2m_1p056";
			regulator-min-microvolt = <1056000>;
			regulator-max-microvolt = <1056000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l3m_2p8: ldo3 {
			regulator-name = "vreg_l3m_2p8";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <2800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l4m_2p8: ldo4 {
			regulator-name = "vreg_l4m_2p8";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <2800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l5m_1p8: ldo5 {
			regulator-name = "vreg_l5m_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l6m_1p8: ldo6 {
			regulator-name = "vreg_l6m_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l7m_2p9: ldo7 {
			regulator-name = "vreg_l7m_2p9";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <2904000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};

	regulators-7 {
		compatible = "qcom,pm8010-rpmh-regulators";
		qcom,pmic-id = "n";

		vreg_l1n_1p1: ldo1 {
			regulator-name = "vreg_l1n_1p1";
			regulator-min-microvolt = <1104000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l2n_1p1: ldo2 {
			regulator-name = "vreg_l2n_1p1";
			regulator-min-microvolt = <1104000>;
			regulator-max-microvolt = <1200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l3n_2p8: ldo3 {
			regulator-name = "vreg_l3n_2p8";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <3000000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l4n_2p8: ldo4 {
			regulator-name = "vreg_l4n_2p8";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <3300000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l5n_1p8: ldo5 {
			regulator-name = "vreg_l5n_1p8";
			regulator-min-microvolt = <1800000>;
			regulator-max-microvolt = <1800000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l6n_3p3: ldo6 {
			regulator-name = "vreg_l6n_3p3";
			regulator-min-microvolt = <3200000>;
			regulator-max-microvolt = <3200000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};

		vreg_l7n_2p96: ldo7 {
			regulator-name = "vreg_l7n_2p96";
			regulator-min-microvolt = <2800000>;
			regulator-max-microvolt = <2960000>;
			regulator-initial-mode = <RPMH_REGULATOR_MODE_HPM>;
		};
	};
};

/*
 * Display clock controller. The DP/qmpphy parent clocks it lists resolve as
 * harmless lazy orphans on this USB2-only board (the DP RCGs are never
 * enabled); the dispcc probe configures only the two display PLLs + the XO,
 * so enabling it without usb_dp_qmpphy is safe.
 */
&dispcc {
	status = "okay";
};

/*
 * Native MIPI-DSI display bring-up. The DPU (mdss_mdp) auto-enables with its
 * &mdss parent; mdss_dp0 stays disabled (no DisplayPort on this USB2-only
 * board). The panel is a direct command-mode AMOLED (Anapass ANA38407 DDIC,
 * Samsung AMSA46AS02 module) on DSI0 lane 0-3. Until its driver
 * (panel-samsung-ana38407-amsa46as02) is loaded, the DSI component defers
 * cleanly on the unbound panel device; the driver then completes the pipeline.
 */
&mdss {
	status = "okay";
};

&mdss_dsi0 {
	vdda-supply = <&vreg_l3e_1p2>;
	status = "okay";

	panel@0 {
		compatible = "samsung,ana38407-amsa46as02";
		reg = <0>;

		/*
		 * Single GPIO-gated panel-power rail (panel_ldo_en, &tlmm 187,
		 * boot-on): it enables the discrete panel-power IC that produces
		 * the panel's VCI/VDDIO/VSP/VSN. This is the only software-
		 * controlled supply the downstream device tree declares for the
		 * panel. (vreg_l12b_1p8 / vreg_l13b_3p0 are kept always-on below
		 * as a defensive guess for the panel's I/O / analog rails,
		 * pending schematic confirmation.)
		 */
		power-supply = <&panel_ldo_en>;

		reset-gpios = <&tlmm 125 GPIO_ACTIVE_LOW>;

		port {
			panel0_in: endpoint {
				remote-endpoint = <&mdss_dsi0_out>;
			};
		};
	};
};

&mdss_dsi0_out {
	remote-endpoint = <&panel0_in>;
	data-lanes = <0 1 2 3>;
};

&mdss_dsi0_phy {
	vdds-supply = <&vreg_l1e_0p88>;
	status = "okay";
};

&pm8550_gpios {
	volume_up_n: volume-up-n-state {
		pins = "gpio6";
		function = "normal";
		power-source = <1>;
		bias-pull-up;
		input-enable;
	};
};

&pm8550vs_c {
	status = "okay";
};

&pm8550vs_d {
	status = "okay";
};

&pm8550vs_e {
	status = "okay";
};

&pm8550vs_g {
	status = "okay";
};

&pon_pwrkey {
	status = "okay";
};

&pon_resin {
	status = "okay";
	linux,code = <KEY_VOLUMEDOWN>;
};

&qupv3_id_0 {
	status = "okay";
};

/*
 * GPI DMA engine for the QUPv3 wrapper-1 buses. i2c4 (below) declares
 * dmas = <&gpi_dma1 ...> in sm8550.dtsi; mainline geni-i2c requests that tx
 * DMA channel at probe and sits in -EPROBE_DEFER forever ("Failed to get tx
 * DMA ch") if the controller is disabled. i2c4 is the first wrap-1 bus we
 * enable on this device, so gpi_dma1 must be turned on for the touchscreen
 * bus to register at all.
 */
&gpi_dma1 {
	status = "okay";
};

/*
 * Goodix gt9916 (Berlin-D) capacitive touchscreen on i2c4 (i2c@a90000),
 * i2c address 0x5d. The bus is confirmed by the stock dtbo's
 * qts,trusted-touch-io-bases = <0xa90000>; the chip identity, GPIOs and
 * rails are this device's own stock values (native goodix-berlin@5d,
 * fragment@19) and agree with the sm8550-qrd reference (gpio25 IRQ /
 * gpio24 reset / avdd = L14B). Mainline goodix_berlin_i2c binds
 * "goodix,gt9916"; firmware is factory-flashed in-IC (no request_firmware).
 * vddio (downstream iovdd = L12B) is omitted to match qrd — that rail is
 * already kept always-on for the panel, so the driver's dummy regulator
 * suffices.
 */
&i2c4 {
	status = "okay";

	touchscreen@5d {
		compatible = "goodix,gt9916";
		reg = <0x5d>;

		interrupt-parent = <&tlmm>;
		interrupts = <25 IRQ_TYPE_LEVEL_LOW>;

		reset-gpios = <&tlmm 24 GPIO_ACTIVE_LOW>;

		avdd-supply = <&vreg_l14b_3p2>;

		pinctrl-names = "default";
		pinctrl-0 = <&ts_irq>, <&ts_reset>;
	};
};

/* gts9u firmware-protected GPIOs = {36,37,38,39} (
 * 2-source-verified: live qcom,gpios-reserved == overlay1).  THE
 * prime ~6 s killer (research cause-1).  Shares q5q's <36 4>
 * Samsung-SM8550-common block; does NOT reserve q5q's Z-Fold5
 * <50 2>. */
&tlmm {
	gpio-reserved-ranges = <36 4>;

	/*
	 * Goodix gt9916 touchscreen IRQ (gpio25) + reset (gpio24). GPIO
	 * numbers + rails extracted from this device's own stock dtbo
	 * (native goodix-berlin@5d, fragment@19) and cross-confirmed against
	 * the sm8550-qrd reference board's gt9916 node. Both clear of the
	 * reserved <36 4> block above.
	 */
	ts_irq: ts-irq-state {
		pins = "gpio25";
		function = "gpio";
		drive-strength = <8>;
		bias-pull-up;
	};

	ts_reset: ts-reset-state {
		pins = "gpio24";
		function = "gpio";
		drive-strength = <8>;
		bias-pull-up;
	};

	/*
	 * Book-cover hall IC interrupt. Transcribed from this device's own
	 * stock hall_irq pinctrl state (fragment@47): pins "gpio107",
	 * function "gpio", drive-strength <2>, input-enable, bias-disable.
	 * bias-disable is deliberate and matches stock -- the hall IC drives
	 * the line itself, so an internal pull would fight it. Clear of the
	 * firmware-reserved <36 4> block above. The second hall on gpio203
	 * (stock hall_wacom, remapped to SW_ROTATE_LOCK) is NOT wired here.
	 */
	hall_cover_n: hall-cover-n-state {
		pins = "gpio107";
		function = "gpio";
		drive-strength = <2>;
		bias-disable;
		input-enable;
	};

	/*
	 * WCN7850 WLAN/BT enable + BT SW-ctrl pinmux. GPIO numbers are this
	 * device's own (stock bt_kiwi: wl-reset = gpio80, bt-reset = gpio81,
	 * bt-sw-ctrl = gpio82); pin attributes copied from the sm8550-qrd
	 * reference. Clear of the firmware-reserved <36 4> block above.
	 */
	wlan_en: wlan-en-state {
		pins = "gpio80";
		function = "gpio";
		drive-strength = <8>;
		bias-pull-down;
	};

	bt_default: bt-default-state {
		bt-en-pins {
			pins = "gpio81";
			function = "gpio";
			drive-strength = <16>;
			bias-disable;
		};

		sw-ctrl-pins {
			pins = "gpio82";
			function = "gpio";
			bias-pull-down;
		};
	};

	/*
	 * LPASS primary serial audio interface -> the four CS35L45 amplifiers.
	 *
	 * Every value below is this device's own, taken from the stock dtbo
	 * overlay (fragment@162), which is what actually runs -- NOT from the
	 * stock base device tree. The base tree defines tdm0_{clk,ws,din,dout}_active
	 * with drive-strength 8, but nothing references those nodes: their phandles
	 * appear exactly once each, at their own definition, and the base tree
	 * contains no pri_mi2s or msm-cdc-pinctrl consumer at all. The nodes the
	 * live system consumes are the overlay's, via
	 * pri_mi2s_pinctrl.pinctrl-0 = <0x258 0x259 0x25a 0x25b>, and they specify
	 * drive-strength 2. A defined-but-unreferenced value is not the hardware's
	 * value.
	 *
	 * Stock:  gpio126 i2s0_sck / gpio129 i2s0_ws  -- 2 mA, bias-disable, output-high
	 *         gpio127 i2s0_data0 / gpio128 i2s0_data1 -- 2 mA, bias-disable
	 * Sleep (from the base tree, which the overlay does not override):
	 *         all four as plain gpio, 2 mA, bias-pull-down, input-enable.
	 *
	 * output-high is transcribed literally and is meaningful here: in mainline
	 * it maps to PIN_CONFIG_LEVEL (pinconf-generic.c:196), which pinctrl-msm
	 * implements as "write the output value, then enable output" -- the same
	 * thing the downstream pinctrl does.
	 */
	mi2s0_active: mi2s0-active-state {
		sck-pins {
			pins = "gpio126";
			function = "i2s0_sck";
			drive-strength = <2>;
			bias-disable;
			output-high;
		};

		ws-pins {
			pins = "gpio129";
			function = "i2s0_ws";
			drive-strength = <2>;
			bias-disable;
			output-high;
		};

		data0-pins {
			pins = "gpio127";
			function = "i2s0_data0";
			drive-strength = <2>;
			bias-disable;
		};

		data1-pins {
			pins = "gpio128";
			function = "i2s0_data1";
			drive-strength = <2>;
			bias-disable;
		};
	};

	mi2s0_sleep: mi2s0-sleep-state {
		pins = "gpio126", "gpio127", "gpio128", "gpio129";
		function = "gpio";
		drive-strength = <2>;
		bias-pull-down;
		input-enable;
	};
};

/* UFS = the rootfs path; q5q-proven supply mapping (SoC+PMIC-level). */
&ufs_mem_hc {
	reset-gpios = <&tlmm 210 GPIO_ACTIVE_LOW>;
	vcc-supply = <&vreg_l17b_2p5>;
	vcc-max-microamp = <1300000>;
	vccq-supply = <&vreg_l1g_1p2>;
	vccq-max-microamp = <1200000>;
	vdd-hba-supply = <&vreg_l3g_1p2>;
	status = "okay";
};

&ufs_mem_phy {
	vdda-phy-supply = <&vreg_l1d_0p88>;
	vdda-pll-supply = <&vreg_l3e_1p2>;
	status = "okay";
};

/*
 * USB host: dwc3 host over eUSB2 (flipped from peripheral/gadget for USB-host
 * bring-up; loses the ttyGS0 gadget serial console -- SSH-over-Wi-Fi is primary).
 * USB2/high-speed only -- no qmpphy/SuperSpeed. NOTE: native port VBUS (5V out)
 * is sourced by the Samsung SM5714 (sm5714-otg) which has no mainline driver --
 * so attached devices need EXTERNAL VBUS (a powered/PD hub or dock). The host
 * data path itself does not depend on that.
 *
 * The NXP PTN3222 eUSB2 repeater conditions the 1.2V eUSB2 signal up to 3.3V
 * USB2 for the connector, so it is electrically required. It sits on SE6 i2c
 * (@898000) -- but that SE is firmware-provisioned as UART on this device, and
 * mainline geni-i2c refuses to re-provision a non-blank SE ("Invalid proto 2"),
 * so the i2c control path is unavailable. The mainline ptn3222 driver issues
 * NO i2c transactions -- it only enables vdd3v3/vdd1v8 and deasserts the reset
 * GPIO -- so the repeater is brought up purely in hardware here: its supplies
 * are kept always-on (see vreg_l5b_3p1 below; vreg_l15b_1p8 is already
 * always-on) and its active-low RESETN (pm8550vs_d gpio4) is held deasserted
 * (driven high) by a gpio-hog. The eUSB2 phy then runs with no repeater
 * sub-phy (phys=<&ptn3222> dropped; the snps-eusb2 driver treats the repeater
 * as optional and no-ops phy_init on a NULL repeater).
 */
&pm8550vs_d_gpios {
	ptn3222_reset_deassert: ptn3222-reset-hog {
		gpio-hog;
		gpios = <4 GPIO_ACTIVE_HIGH>;
		output-high;
		line-name = "ptn3222-resetn-deassert";
	};
};

&usb_1 {
	status = "okay";
	/*
	 * Dual-role (DRD): the data role is driven by the SM5714 Type-C
	 * controller (sm5714-typec, usbpd@33 below) through the standard
	 * usb_role_switch the dwc3 core registers in OTG mode (the base
	 * "usb-role-switch" property is inherited from sm8550.dtsi).  HOST when a
	 * peripheral is attached (the PDIC also turns on OTG VBUS), DEVICE/gadget
	 * when a charger or host PC is attached.  USB2/high-speed only.
	 */
	dr_mode = "otg";
	phys = <&usb_1_hsphy>;
	phy-names = "usb2-phy";
	maximum-speed = "high-speed";

	/*
	 * USB2/high-speed only -- no SuperSpeed QMP PHY, so nothing drives the
	 * controller's PIPE clock. Without this, the DWC32 core soft reset
	 * (DCTL.CSFTRST) never completes -- it blocks until all clock domains
	 * synchronize, and the unfed PIPE domain never does -- so the controller
	 * probe fails with -ETIMEDOUT. This makes the qcom glue feed the UTMI
	 * clock into the PIPE domain instead, satisfying the reset.
	 */
	qcom,select-utmi-as-pipe-clk;
};

&usb_1_hsphy {
	vdd-supply = <&vreg_l1e_0p88>;
	vdda12-supply = <&vreg_l3e_1p2>;
	status = "okay";
};

&sleep_clk {
	clock-frequency = <32764>;
};

&xo_board {
	clock-frequency = <76800000>;
};

&pmk8550 {
	/*
	 * PMIC5 Gen3 ADC (SDAM-based engine in PMK8550, multi-PMIC via SID-routed
	 * virtual channels). The battery cell thermistor is wired to PM8550
	 * AMUX1_THM, virtual channel 0x144 (SID 1 << 8 | channel 0x44), a
	 * 100k-pullup NTC. This is the true cell temperature stock gates cell-charge
	 * safety on (downstream battery,thermal_source = ADC) -- distinct from the
	 * SM5714 fuel-gauge die temperature exposed as POWER_SUPPLY_PROP_TEMP. The
	 * driver returns this channel as IIO_TEMP (millidegC) via its 100k-pullup
	 * thermistor scaling.
	 */
	pmk8550_vadc: adc@9000 {
		compatible = "qcom,spmi-adc5-gen3";
		reg = <0x9000>, <0x9100>;
		#address-cells = <1>;
		#size-cells = <0>;
		#io-channel-cells = <1>;
		interrupts = <0x0 0x90 0x1 IRQ_TYPE_EDGE_RISING>,
			     <0x0 0x91 0x1 IRQ_TYPE_EDGE_RISING>;
		interrupt-names = "adc-sdam0", "adc-sdam1";

		channel@144 {
			reg = <0x144>;
			label = "batt_therm";
			qcom,ratiometric;
			qcom,hw-settle-time = <200>;
			qcom,pre-scaling = <1 1>;
		};
	};
};

&pmk8550_gpios {
	/* 32 kHz sleep-clock output routed to the WCN7850 (PMIC gpio3 func1). */
	pmk8550_sleep_clk: sleep-clk-state {
		pins = "gpio3";
		function = "func1";
		input-disable;
		output-enable;
		bias-disable;
		power-source = <0>;
	};
};

/*
 * PCIe0 root complex -- the WCN7850 Wi-Fi endpoint sits here. PERST# (gpio94)
 * and WAKE# (gpio96) are SoC-dedicated PCIe0 pins: sm8550.dtsi's
 * pcie0_default_state pins gpio94/95/96 to perst / pcie0_clk_req_n / wake, so
 * they are fixed by the SoC (not board-routed) and the QRD reference uses the
 * same. CLKREQ# (gpio95) is handled by the pinctrl default state.
 */
&pcie0 {
	perst-gpios = <&tlmm 94 GPIO_ACTIVE_LOW>;
	wake-gpios = <&tlmm 96 GPIO_ACTIVE_HIGH>;

	pinctrl-0 = <&pcie0_default_state>;
	pinctrl-names = "default";

	status = "okay";
};

&pcie0_phy {
	vdda-phy-supply = <&vreg_l1e_0p88>;
	vdda-pll-supply = <&vreg_l3e_1p2>;

	status = "okay";
};

/*
 * WCN7850 Wi-Fi endpoint (mainline ath12k; PCI 17cb:1107). Its supplies are
 * the WCN PMU's LDO outputs (vreg_pmu_*, from the wcn7850-pmu node above) and
 * are copied verbatim from the sm8550-qrd reference -- the supply set is
 * chip-intrinsic, not board-specific.
 */
&pcieport0 {
	wifi@0 {
		compatible = "pci17cb,1107";
		reg = <0x10000 0x0 0x0 0x0 0x0>;

		vddrfacmn-supply = <&vreg_pmu_rfa_cmn>;
		vddaon-supply = <&vreg_pmu_aon_0p59>;
		vddwlcx-supply = <&vreg_pmu_wlcx_0p8>;
		vddwlmx-supply = <&vreg_pmu_wlmx_0p85>;
		vddrfa0p8-supply = <&vreg_pmu_rfa_0p8>;
		vddrfa1p2-supply = <&vreg_pmu_rfa_1p2>;
		vddrfa1p8-supply = <&vreg_pmu_rfa_1p8>;
		vddpcie0p9-supply = <&vreg_pmu_pcie_0p9>;
		vddpcie1p8-supply = <&vreg_pmu_pcie_1p8>;
	};
};

/*
 * Adreno 740 GPU. The SoC dtsi ships gpu@3d00000 status="disabled"; enable it
 * here. The GMU (gmu@3d6a000) and adreno_smmu (iommu@3da0000) carry no status
 * property, so they cascade to "okay" from the GPU node. SQE (a740_sqe.fw) and
 * GMU (gmu_gen70200.bin) firmware are auto-derived from the chip-id by the
 * driver and need no firmware-name. The zap shader is a PAS-signed image whose
 * trust chain is rooted in this device's QFPROM fuses, so the generic
 * linux-firmware zap is rejected by TrustZone; point firmware-name at the
 * device-extracted, Samsung-signed blob at a device-specific path so a stock
 * linux-firmware-qcom install cannot shadow it at the shared qcom/sm8550 path.
 */
&gpu {
	status = "okay";
};

&gpu_zap_shader {
	firmware-name = "qcom/sm8550/samsung/gts9u/a740_zap.mbn";
};

/*
 * Bluetooth — the device's own WCN7850 ("kiwi") BT controller over UART.
 *
 * GOLDEN-RULE value (this device's own downstream source): the stock BT HCI
 * transport is qcom,qup_uart@898000 = qupv3_se14_4uart, on QUPv3 wrapper 2
 * Serial Engine 6 (GCC_QUPV3_WRAP2_S6_CLK) — mainline's uart14. It is a
 * 4-wire port with real hardware flow control:
 *
 *   gpio76 CTS  qup2_se6_l0        gpio78 TX  qup2_se6_l2
 *   gpio77 RTS  qup2_se6_l1        gpio79 RX  qup2_se6_l3
 *
 * Sources: kalama-qupv3.dtsi qupv3_se14_4uart (the SoC node), kalama-pinctrl.dtsi
 * qupv3_se14_4uart_pins (its active pin states), and the board fragment that
 * sets that node status = "ok". Corroborated on the live stock system, where
 * the Bluetooth HAL holds /dev/ttyHS0 = 898000.qcom,qup_uart as its only tty,
 * that engine accrues ~277 s of runtime-PM active time against 278 ms for
 * a9c000, and its node is owned bluetooth:net_bt while a9c000 is root:radio.
 * The pads form one contiguous run with the WCN7850 control pins already
 * confirmed from the stock bt_kiwi node: 76 CTS, 77 RTS, 78 TX, 79 RX,
 * 80 WLAN_EN, 81 BT_EN, 82 SW_CTRL.
 *
 * This corrects an earlier binding to &uart7 (SE7, 0xa9c000, gpio26/27), which
 * came from reading a node NAMED qupv3_se7_2hsuart_pins as "2-wire, therefore
 * Bluetooth". The stock bt_kiwi node names no UART at all, and gpio26/27 sit
 * beside gpio24/25, which belong to the Goodix touchscreen. Hardware flow
 * control is therefore left ON — the earlier qcom,disable-hw-flow-control
 * opt-out existed only because CTS/RTS were believed absent.
 *
 * Pinctrl is inherited from sm8550.dtsi (qup_uart14_default = gpio78/79,
 * qup_uart14_cts_rts = gpio76/77, function qup2_se6, drive-strength 2),
 * verified pad-for-pad against the device's own values. Two idle-bias deltas
 * are known and deliberately left at mainline's values, which are also what
 * the in-tree sm8550-qrd.dts reference uses for this same chip: mainline
 * biases gpio76 CTS pull-down where stock leaves it bias-disable, and gpio79
 * RX pull-up where stock leaves it bias-disable. Both are permissive on lines
 * driven push-pull at each end.
 *
 * Power is owned by the wcn7850-pmu pwrseq node above (bt-enable-gpios =
 * TLMM 81); per the mainline-qrd convention the bluetooth node OMITS
 * enable-gpios and only lists its supplies (the PMU's vreg_pmu_* LDOs).
 */
&uart14 {
	status = "okay";

	bluetooth {
		compatible = "qcom,wcn7850-bt";

		vddrfacmn-supply = <&vreg_pmu_rfa_cmn>;
		vddaon-supply = <&vreg_pmu_aon_0p59>;
		vddwlcx-supply = <&vreg_pmu_wlcx_0p8>;
		vddwlmx-supply = <&vreg_pmu_wlmx_0p85>;
		vddrfa0p8-supply = <&vreg_pmu_rfa_0p8>;
		vddrfa1p2-supply = <&vreg_pmu_rfa_1p2>;
		vddrfa1p8-supply = <&vreg_pmu_rfa_1p8>;

		max-speed = <3200000>;

		/*
		 * NVM selection. btqca asks the controller for a board ID and
		 * builds the NVM name from it (qca_get_nvm_name_by_board); this
		 * controller answers 0/0xffff, so the driver falls back to the bare
		 * qca/hmtnv20.bin. That file, from the device's own vendor image, is
		 * the BTFW.HAMILTON_C.2.0.1-00128 build, while the rampatch we load
		 * (qca/hmtbtfw20.tlv) is -00280. The controller accepts the rampatch
		 * and then answers the first NVM TLV segment with HCI status 0x0C
		 * "Command Disallowed" (-EBADE), so setup fails.
		 *
		 * firmware-name[0] overrides the NVM name (firmware-name[1] would
		 * override the rampatch; leaving it unset keeps the default). Name
		 * the -00280 NVM explicitly. Of the device's three shipped variants
		 * hmtnv20.b21 / .b22 / .b38, b22 and b38 are byte-identical and b22
		 * is the one this controller was measured to accept, after which it
		 * reports BTFW.HAMILTON_C.2.0.1-00280-PATCHZ-1.52014.13 running.
		 */
		firmware-name = "hmtnv20.b22";

		/*
		 * The controller has no BD address programmed: Read BD ADDR returns
		 * 00:00:00:00:5A:AD, so BlueZ raises "Unconfigured Index Added" and
		 * refuses to power the adapter. hci_dev_get_bd_addr_from_property()
		 * reads this property and, exactly when the controller's own address
		 * is invalid and hdev->set_bdaddr exists (both true here), programs
		 * it via the QCA vendor command.
		 *
		 * GOLDEN-RULE value: this device's OWN factory address, read from
		 * its EFS partition at /efs/bluetooth/bt_addr = 08:A5:DF:7E:7A:1E.
		 * (Its Wi-Fi MAC in /efs/wifi/.mac.info is ...:1F; the BT address was
		 * read, not derived from it.) bdaddr_t is little-endian, so the bytes
		 * are the address reversed. Do NOT add qcom,local-bd-address-broken:
		 * that sets HCI_QUIRK_BDADDR_PROPERTY_BROKEN, which byte-swaps again.
		 */
		local-bd-address = [1E 7A 7E DF A5 08];
	};
};

/*
 * Book Cover Keyboard (R12) — Samsung stm32_pogo_v3 over i2c15.
 *
 * The cover is an STM32 MCU on the pogo connector at i2c address 0x2a, on
 * qupv3_se15 = mainline i2c15 (i2c@89c000, QUPv3 wrapper-2). Bring-up mirrors
 * the i2c4 touchscreen pattern: the parent QUP controller (qupv3_id_1) and its
 * GPI DMA engine (gpi_dma2) are disabled in sm8550.dtsi and must be enabled, or
 * geni-i2c sits in -EPROBE_DEFER forever ("Failed to get tx DMA ch"). The bus
 * SCL/SDA pinmux (qup_i2c15_data_clk) is inherited from sm8550.dtsi.
 *
 * All node/GPIO/property values are this device's own (gts9uwifi r03 stm32@2a +
 * its fixed_regulator@1 I/O rail + its attn/conn/swclk/nrst pinmux).
 */
&qupv3_id_1 {
	status = "okay";
};

&gpi_dma2 {
	status = "okay";
};

&tlmm {
	kbd_attn_irq: kbd-attn-irq-state {
		pins = "gpio75";
		function = "gpio";
		drive-strength = <2>;
		input-enable;
		bias-disable;
	};

	kbd_conn_irq: kbd-conn-irq-state {
		pins = "gpio62";
		function = "gpio";
		drive-strength = <2>;
		input-enable;
		bias-disable;
	};

	kbd_swclk: kbd-swclk-state {
		pins = "gpio12";
		function = "gpio";
		drive-strength = <2>;
		bias-disable;
		output-low;
	};

	kbd_nrst: kbd-nrst-state {
		pins = "gpio13";
		function = "gpio";
		drive-strength = <2>;
		bias-disable;
		output-high;
	};

	kbd_ldo_en: kbd-ldo-en-state {
		pins = "gpio10";
		function = "gpio";
		bias-disable;
	};
};

&i2c15 {
	status = "okay";

	keyboard@2a {
		compatible = "stm,stm32_pogo";
		reg = <0x2a>;

		pinctrl-names = "default";
		pinctrl-0 = <&kbd_attn_irq>, <&kbd_conn_irq>,
			    <&kbd_swclk>, <&kbd_nrst>;

		stm32_vddo-supply = <&kbd_stm32_vddo>;

		stm32,irq_gpio = <&tlmm 75 GPIO_ACTIVE_HIGH>;
		stm32,irq_conn = <&tlmm 62 GPIO_ACTIVE_HIGH>;
		stm32,irq_type = <0x2008>;	/* IRQF_ONESHOT | IRQF_TRIGGER_LOW */
		stm32,irq_conn_type = <0x2003>;	/* IRQF_ONESHOT | RISING | FALLING */
		stm32,mcu_swclk = <&tlmm 12 GPIO_ACTIVE_HIGH>;
		stm32,mcu_nrst = <&tlmm 13 GPIO_ACTIVE_HIGH>;
		stm32,sda_gpio = <&tlmm 72 GPIO_ACTIVE_HIGH>;
		stm32,scl_gpio = <&tlmm 106 GPIO_ACTIVE_HIGH>;
		stm32,fw_name = "keyboard_stm/stm32_gts9family.bin";
		stm32,model_name = "EF-DX915\0EF-DX910\0EF-DX900\0EF-DX925\0EF-DX920";
		stm32,fota_fw_path = [00];
		support_open_close;
		stm32,booster_power_models = <0xf9 0xd3>;
		stm32,booster_power_voltage = <0x7d7d0>;	/* 514000 uV */
	};
};

/*
 * Silicon Mitus SM5714 PMIC control bus (USB-host VBUS bring-up).
 *
 * The USB-C port's 5V VBUS boost (downstream "sm5714-otg") lives inside the
 * SM5714 charger block, reached over I2C at 7-bit addr 0x49. The device's own
 * downstream DT places the SM5714 MFD on qupv3_hub_i2c8 (i2c@9a0000) = mainline
 * &i2c_hub_8, inside the I2C-master-hub wrapper &i2c_master_hub_0 (geniqup@9c0000).
 *
 * That hub is a dedicated I2C-only QUP (compatible "qcom,geni-i2c-master-hub",
 * FIFO/no-DMA) -- it is NOT a general geniqup SE that firmware multiplexes to
 * UART/SPI, so the "Invalid proto 2" provisioning wall (which blocks the eUSB2
 * repeater's SE6 i2c above) does not apply here, and there is no GPI-DMA
 * dependency to -EPROBE_DEFER on. SDA gpio206 / SCL gpio207 (i2chub0_se8),
 * pinctrl + clocks + interconnects all inherited from sm8550.dtsi.
 *
 * The SM5714 charger block (0x49) is claimed by the sm5714-usb-vbus driver,
 * which drives both the OTG VBUS boost (charger 0x49) and the USB2 data-path
 * com switch (MUIC 0x25, a secondary i2c client it creates). USB host mode is
 * off by default -- the SM5714 cannot source VBUS and charge the battery at the
 * same time -- and is enabled on demand via the driver's "host_vbus" sysfs
 * attribute. Add "siliconmitus,vbus-always-on" below to bring host mode up
 * automatically at boot instead (note: that prevents charging while running).
 */
&i2c_master_hub_0 {
	status = "okay";
};

/*
 * SM5440 switched-capacitor 2:1 charge-pump bus (rung-3 45 W fast charge).
 * The SM5440 lives at i2c 7-bit 0x63 on i2c-hub serial-engine SE3
 * (i2c@98c000 = mainline &i2c_hub_3), a third SE inside the same
 * &i2c_master_hub_0 wrapper as the SM5714 buses below. The device's own
 * downstream DT places it on qupv3_hub_i2c3. Pinned to i2c-2 via the root
 * aliases node so enabling it does not renumber the SM5714 buses.
 */
&i2c_hub_3 {
	status = "okay";
	clock-frequency = <400000>;

	/*
	 * SM5440 charge pump.  The sm5440_charger telemetry/register driver
	 * (rung-3 Component 1) probes here, gates on the DEVICEID (low nibble
	 * 0x1), enables the on-chip ADC, and exposes input voltage / input
	 * current / die temperature as a power_supply.  It leaves op-mode at
	 * its CHG_OFF default, never controls charging, and consumes no
	 * device-tree tuning.  The device's own pump-tuning values -- freq
	 * 450, r_ttl 500000, freq_siop <250 250>, en_vbatreg 0 (downstream
	 * qupv3_hub_i2c3: sm5440@63) -- are reintroduced under manufacturer-
	 * prefixed property names, with a driver that consumes them, by the
	 * later fast-charge control component; they are deliberately not
	 * carried here so the node validates against the upstream binding.
	 */
	charger@63 {
		compatible = "siliconmitus,sm5440";
		reg = <0x63>;
	};
};

/*
 * Cirrus Logic CS35L45 quad speaker-amplifier control bus.
 *
 * The tablet's four speakers are driven by four CS35L45 smart amplifiers
 * sharing ONE I2C control bus, ONE reset line and ONE interrupt line. Every
 * value below is transcribed from this device's own stock dtbo (gts9uwifi
 * r03, fragment@160), not from a sister device.
 *
 * The bus is qupv3_hub_i2c6 (i2c@998000) = mainline &i2c_hub_6, a fourth
 * serial engine inside the same &i2c_master_hub_0 wrapper as the SM5714 and
 * SM5440 buses above. That mapping is not inferred: the overlay's __fixups__
 * node names the target label verbatim, "qupv3_hub_i2c6 =
 * /fragment@160:target:0", and fragment@160 is the fragment holding all four
 * amp nodes. clock-frequency mirrors stock's qcom,clk-freq-out = <0xf4240>
 * (1 MHz). Pinned to i2c-3 via the root aliases node so that enabling this
 * bus cannot renumber the charging buses that tools address as /dev/i2c-0.
 *
 * ADDRESSES AND PLACEMENT (stock node names -> cirrus,bd-suffix, which is how
 * stock selects each amp's per-unit calibration blob):
 *   0x30 cs35l45-rearleft   _2      0x31 cs35l45-frontleft   _0
 *   0x32 cs35l45-rearright  _3      0x33 cs35l45-frontright  _1
 *
 * WHAT THIS NODE DOES NOT DO. I2C here is CONTROL only. Audio data reaches
 * the amps over the LPASS primary port on TLMM gpio126/127/128/129 (stock
 * pri_mi2s_pinctrl; mux functions i2s0_sck / i2s0_data0 / i2s0_data1 /
 * i2s0_ws, which mainline's sm8550 TLMM carries under exactly those names),
 * as four TDM slots at 48 kHz / 24-bit — the device's own PAL backend
 * definition is TDM-LPAIF-RX-PRIMARY with <channels>4</channels>. Driving
 * that needs a sound card plus an AudioReach topology binary, and mainline
 * currently has neither the TDM DAI ops on the q6apm path nor an SM8550
 * topology containing any I2S/TDM module. So no sound-card node is described
 * here: these nodes bring the amplifiers up as I2C devices and nothing more.
 * The in-tree sm8550-sony-xperia-yodo-pdx234.dts declares its CS35L45s the
 * same way, with no card anywhere.
 *
 * RESET is shared by all four amps on TLMM 42, and the polarity is
 * ACTIVE_HIGH — stock's flag cell is 0x00, and mainline's driver acquires the
 * line GPIOD_OUT_LOW then drives logical 1 to release reset
 * (cs35l45.c:1399,1413), so logical 1 must be physically high. Declaring it
 * on all four nodes is correct and intended: the driver comments "If reset is
 * shared only one instance can claim it", takes -EBUSY on the other three and
 * continues (cs35l45.c:1398).
 *
 * INTERRUPTS are wired as stock wires them: all four amplifiers share TLMM 14.
 * The stock overlay carries interrupts = <0x0e 0x00> on each amp node with
 * interrupt-parent resolved to &tlmm through __fixups__, which names all four
 * explicitly. The second cell is 0 there because the vendor driver supplies the
 * polarity itself; mainline's does the same, ORing in IRQF_TRIGGER_LOW (or HIGH
 * when cirrus,gpio-ctrl2 sets irq_invert) together with IRQF_SHARED at
 * cs35l45.c:1428-1439, so the type is spelled IRQ_TYPE_LEVEL_LOW here to say
 * out loud what both drivers request.
 *
 * This was omitted for several sessions on the grounds that a level-triggered
 * shared line had no business on a boot whose only job was to find out whether
 * the amplifiers answered on I2C at all. They answer now, so that reason has
 * expired -- and the interrupt is not decoration: it is how a CS35L45 reports
 * over-temperature, over-current and short-circuit. An amplifier driven without
 * its fault line is an amplifier whose protection reporting we have declined to
 * connect, which is not what stock does.
 *
 * No pinctrl entry is needed for gpio14: the TLMM irqchip muxes a line to its
 * GPIO function when the interrupt is requested. Stock's cs35l45_gpio_default
 * (gpio14 + gpio42, function "gpio", bias-disable, drive-strength 2) matches
 * the TLMM defaults for these pins.
 *
 * No pinctrl is declared: gpiolib's request path muxes a TLMM pin to its GPIO
 * function on its own, and four devices naming one pin group would collide in
 * mainline's pinmux. Stock's cs35l45_gpio_default (gpio14 + gpio42, function
 * "gpio", bias-disable, drive-strength 2) matches the TLMM defaults for these
 * pins.
 */
/*
 * PIN CONFIGURATION FOR THE AMPLIFIER BUS -- both values taken from this
 * device's own stock device tree, not from the SoC defaults.
 *
 * DRIVE STRENGTH 8 mA. The SoC base (kalama-pinctrl.dtsi:2471-2496, and
 * mainline's own hub_i2c6_data_clk at sm8550.dtsi:4691-4697) declares these
 * pins at 2 mA. This board's overlay overrides BOTH of them to 8 mA --
 * fragment@166 for SDA and fragment@167 for SCL, each a bare
 * "config { drive-strength = <0x08>; }" -- and i2c6 is the ONLY hub bus on
 * this board that gets the override. It is also the only one stock runs at
 * 1 MHz. Mainline had taken the 1 MHz and left the 2 mA: half a value pair.
 *
 * 🔴 This is NOT what fixed the transfer stall, and the record should be
 * clear about that: an A/B measured on this hardware, taking both pads from
 * 2 mA to 8 mA and reading the TLMM control registers back to prove it
 * landed, moved the transfer time by 0.01 units out of 74. The stall was the
 * Fast-mode-plus SCL high time, fixed in the driver's clock map. 8 mA is here
 * because it is what the manufacturer specifies for this bus driving these
 * four amplifiers, and a value this device's own source states is not
 * optional on the grounds that one measurement did not need it.
 *
 * SLEEP STATE. Stock declares qupv3_hub_i2c6_sleep alongside the active
 * states: both pins back to plain "gpio" at 2 mA. It is live, not decorative
 * -- geni_se_resources_off() calls pinctrl_pm_select_sleep_state()
 * (qcom-geni-se.c:601) on every runtime suspend, and this bus autosuspends
 * after 250 ms. Bias is deliberately left unspecified, exactly as stock leaves
 * it, so the pull is carried over from the active state rather than reset.
 */
&hub_i2c6_data_clk {
	drive-strength = <8>;
};

&tlmm {
	hub_i2c6_sleep: hub-i2c6-sleep-state {
		/* SDA, SCL */
		pins = "gpio8", "gpio9";
		function = "gpio";
		drive-strength = <2>;
	};
};

&i2c_hub_6 {
	status = "okay";
	clock-frequency = <1000000>;

	pinctrl-names = "default", "sleep";
	pinctrl-0 = <&hub_i2c6_data_clk>;
	pinctrl-1 = <&hub_i2c6_sleep>;

	/*
	 * Per-unit factory speaker calibration.
	 *
	 * These are measurements of THIS tablet's four drivers, not board
	 * constants, recorded by the factory on 2023-12-11. They live on the
	 * device in the sec_efs partition (/dev/disk/by-partlabel/sec_efs) under
	 * /cirrus, as ASCII decimal in 12-byte files keyed by an amplifier
	 * suffix. They are carried here because nothing in this system reads
	 * that partition, and because the protection firmware zeroes CAL_R every
	 * time its tuning .bin loads.
	 *
	 * The suffix-to-amplifier mapping is joined on the i2c address -- the
	 * only invariant that cannot be misread -- using this device's own stock
	 * dtbo. The intuitive reading of the suffixes is WRONG on all four:
	 *
	 *   0x30 cs35l45-rearleft    ""     0x31 cs35l45-frontleft   _b
	 *   0x32 cs35l45-rearright   _r     0x33 cs35l45-frontright  _br
	 *
	 * so "_r" is REAR-right and "_b" is FRONT-left. The four rdc values span
	 * only 2.8%, so a wrong assignment would produce a plausible, error-free
	 * result that no measurement could detect. Do not "correct" these by
	 * name; re-derive from the i2c address.
	 *
	 * Note cirrus,bd-suffix in the stock dtbo is a DIFFERENT suffix (the TDM
	 * slot index) and must not be confused with the calibration suffix.
	 *
	 * cal-vsc/cal-isc are signed 24-bit trims stored zero-filled in 32 bits;
	 * 0x00FFFF97 is -105. They must not be sign-extended.
	 */
	spkr_amp_rl: speaker-amp@30 {
		compatible = "cirrus,cs35l45";
		reg = <0x30>;

		reset-gpios = <&tlmm 42 GPIO_ACTIVE_HIGH>;

		interrupt-parent = <&tlmm>;
		interrupts = <14 IRQ_TYPE_LEVEL_LOW>;

		vdd-a-supply = <&vreg_spkr_amp>;
		vdd-batt-supply = <&vreg_spkr_amp>;

		cirrus,asp-sdout-hiz-ctrl = <(CS35L45_ASP_TX_HIZ_UNUSED |
					      CS35L45_ASP_TX_HIZ_DISABLED)>;

		#sound-dai-cells = <1>;
		sound-name-prefix = "SpkrRearLeft";

		/* factory calibration -- rdc_cal    / vsc_cal    / isc_cal */
		cirrus,cal-rdc = <8737>;
		cirrus,cal-vsc = <2338>;
		cirrus,cal-isc = <410>;
		cirrus,cal-ambient = <29>;

		CS35L45_GTS9U_NOISE_GATE_CONFIG

		cirrus,gpio-ctrl1 {
			gpio-ctrl = <0x2>;
		};

		cirrus,gpio-ctrl2 {
			gpio-ctrl = <0x2>;
		};

		CS35L45_GTS9U_BPE_CONFIG
		CS35L45_GTS9U_POWER_MODE_CONFIG
	};

	spkr_amp_fl: speaker-amp@31 {
		compatible = "cirrus,cs35l45";
		reg = <0x31>;

		reset-gpios = <&tlmm 42 GPIO_ACTIVE_HIGH>;

		interrupt-parent = <&tlmm>;
		interrupts = <14 IRQ_TYPE_LEVEL_LOW>;

		vdd-a-supply = <&vreg_spkr_amp>;
		vdd-batt-supply = <&vreg_spkr_amp>;

		cirrus,asp-sdout-hiz-ctrl = <(CS35L45_ASP_TX_HIZ_UNUSED |
					      CS35L45_ASP_TX_HIZ_DISABLED)>;

		#sound-dai-cells = <1>;
		sound-name-prefix = "SpkrFrontLeft";

		/* factory calibration -- rdc_cal_b  / vsc_cal_b  / isc_cal_b */
		cirrus,cal-rdc = <8653>;
		cirrus,cal-vsc = <1765>;
		cirrus,cal-isc = <101>;
		cirrus,cal-ambient = <29>;

		CS35L45_GTS9U_NOISE_GATE_CONFIG

		cirrus,gpio-ctrl1 {
			gpio-ctrl = <0x2>;
		};

		cirrus,gpio-ctrl2 {
			gpio-ctrl = <0x2>;
		};

		CS35L45_GTS9U_BPE_CONFIG
		CS35L45_GTS9U_POWER_MODE_CONFIG
	};

	spkr_amp_rr: speaker-amp@32 {
		compatible = "cirrus,cs35l45";
		reg = <0x32>;

		reset-gpios = <&tlmm 42 GPIO_ACTIVE_HIGH>;

		interrupt-parent = <&tlmm>;
		interrupts = <14 IRQ_TYPE_LEVEL_LOW>;

		vdd-a-supply = <&vreg_spkr_amp>;
		vdd-batt-supply = <&vreg_spkr_amp>;

		cirrus,asp-sdout-hiz-ctrl = <(CS35L45_ASP_TX_HIZ_UNUSED |
					      CS35L45_ASP_TX_HIZ_DISABLED)>;

		#sound-dai-cells = <1>;
		sound-name-prefix = "SpkrRearRight";

		/* factory calibration -- rdc_cal_r  / vsc_cal_r  / isc_cal_r */
		cirrus,cal-rdc = <8893>;
		cirrus,cal-vsc = <3170>;
		cirrus,cal-isc = <0x00FFFF97>;
		cirrus,cal-ambient = <29>;

		CS35L45_GTS9U_NOISE_GATE_CONFIG

		cirrus,gpio-ctrl1 {
			gpio-ctrl = <0x2>;
		};

		cirrus,gpio-ctrl2 {
			gpio-ctrl = <0x2>;
		};

		CS35L45_GTS9U_BPE_CONFIG
		CS35L45_GTS9U_POWER_MODE_CONFIG
	};

	spkr_amp_fr: speaker-amp@33 {
		compatible = "cirrus,cs35l45";
		reg = <0x33>;

		reset-gpios = <&tlmm 42 GPIO_ACTIVE_HIGH>;

		interrupt-parent = <&tlmm>;
		interrupts = <14 IRQ_TYPE_LEVEL_LOW>;

		vdd-a-supply = <&vreg_spkr_amp>;
		vdd-batt-supply = <&vreg_spkr_amp>;

		cirrus,asp-sdout-hiz-ctrl = <(CS35L45_ASP_TX_HIZ_UNUSED |
					      CS35L45_ASP_TX_HIZ_DISABLED)>;

		#sound-dai-cells = <1>;
		sound-name-prefix = "SpkrFrontRight";

		/* factory calibration -- rdc_cal_br / vsc_cal_br / isc_cal_br */
		cirrus,cal-rdc = <8722>;
		cirrus,cal-vsc = <2536>;
		cirrus,cal-isc = <49>;
		cirrus,cal-ambient = <29>;

		CS35L45_GTS9U_NOISE_GATE_CONFIG

		cirrus,gpio-ctrl1 {
			gpio-ctrl = <0x2>;
		};

		cirrus,gpio-ctrl2 {
			gpio-ctrl = <0x2>;
		};

		CS35L45_GTS9U_BPE_CONFIG
		CS35L45_GTS9U_POWER_MODE_CONFIG
	};
};

&i2c_hub_8 {
	status = "okay";
	clock-frequency = <400000>;

	usb_vbus: usb-vbus@49 {
		compatible = "siliconmitus,sm5714-usb-vbus";
		reg = <0x49>;
		/*
		 * Cell-temperature NTC for the charge thermal gate: the external
		 * battery thermistor on the PM8550 gen3 PMIC ADC (AMUX1, virtual
		 * channel 0x144), read in place of the SM5714 fuel-gauge die temp
		 * (the device's own stack sets battery,thermal_source = ADC).
		 */
		io-channels = <&pmk8550_vadc 0x144>;
		io-channel-names = "batt-therm";
		/* siliconmitus,vbus-always-on; */
	};

	/*
	 * SM5714 battery fuel-gauge sub-block (read-only).  Same chip, same
	 * bus, separate i2c address -- exposes capacity / voltage / current /
	 * temperature as a POWER_SUPPLY_TYPE_BATTERY so the desktop has a real
	 * battery indicator.  The fuel-gauge IC is cell-powered and keeps the
	 * vendor-programmed model table across reboots, so no parameter push.
	 */
	fuelgauge: fuelgauge@71 {
		compatible = "siliconmitus,sm5714-fuelgauge";
		reg = <0x71>;
		monitored-battery = <&battery>;
	};
};

/*
 * SM5714 Type-C PD/role controller (PDIC) bus.
 *
 * The USB-C cable-orientation / role-detect block (downstream "sm5714-usbpd")
 * lives at i2c 7-bit addr 0x33 -- on a SECOND i2c-hub serial engine, SE9
 * (i2c@9a4000 = mainline &i2c_hub_9), a sibling of the SE8 above inside the
 * same dedicated I2C-master-hub wrapper &i2c_master_hub_0. The device's own
 * downstream DT places it here (overlay fragment@46 -> qupv3_hub_i2c9); a
 * vestigial "i2c-gpio,delay-us" property in that overlay misleadingly suggests
 * a bitbanged bus, but the resolved node is a hardware geni i2c controller --
 * SDA gpio84 / SCL gpio85 (i2chub0_se9), pinctrl/clocks inherited from
 * sm8550.dtsi, identical in shape to SE8.
 *
 * The usbpd@33 child binds the sm5714-typec role driver, which programs
 * autonomous DRP (CC_CNTL1 0x29=0x40), decodes CC_STATUS (reg 0x28: 0x01=source
 * on cable -> DEVICE, 0x02=sink on cable -> HOST, 0x03=audio), and drives the
 * dwc3 usb_role_switch + the SM5714 OTG VBUS.  The PDIC interrupt is gpio133.
 */
&tlmm {
	typec_int_default: typec-int-state {
		pins = "gpio133";
		function = "gpio";
		bias-disable;
		input-enable;
	};
};

&i2c_hub_9 {
	status = "okay";
	clock-frequency = <400000>;

	usbpd@33 {
		compatible = "siliconmitus,sm5714-typec";
		reg = <0x33>;

		interrupt-parent = <&tlmm>;
		interrupts = <133 IRQ_TYPE_LEVEL_LOW>;
		pinctrl-names = "default";
		pinctrl-0 = <&typec_int_default>;

		connector {
			compatible = "usb-c-connector";
			label = "USB-C";
			power-role = "dual";
			data-role = "dual";
			try-power-role = "sink";

			/*
			 * PD capabilities the tcpm policy engine
			 * (drivers/usb/typec/tcpm) reads from this connector
			 * node.  A DRP port must advertise BOTH source and sink.
			 * source-pdos: 5 V only, 900 mA -- the SM5714 OTG boost's
			 * hardware current limit (sm5714-usb-vbus.c BSTCNTL1); a
			 * higher advertisement would be electrically dishonest.
			 * sink-pdos: 5 V + 9 V fixed (the charge-pump input rail)
			 * plus a PPS APDO spanning the fast-charge window.
			 */
			source-pdos = <PDO_FIXED(5000, 900,
						 PDO_FIXED_DUAL_ROLE |
						 PDO_FIXED_USB_COMM |
						 PDO_FIXED_DATA_SWAP)>;
			sink-pdos = <PDO_FIXED(5000, 3000,
					       PDO_FIXED_USB_COMM |
					       PDO_FIXED_DATA_SWAP)
				     PDO_FIXED(9000, 3000, 0)
				     PDO_PPS_APDO(3300, 11000, 5000)>;
			op-sink-microwatt = <2500000>;

			port {
				sm5714_hs_ep: endpoint {
					remote-endpoint = <&usb_1_dwc3_hs>;
				};
			};
		};
	};
};

&usb_1_dwc3_hs {
	remote-endpoint = <&sm5714_hs_ep>;
};

/*
 * ADSP (LPASS) remoteproc -- the keystone for pmic_glink (battery / USB-C PD /
 * DP-altmode) and for CPU-offload audio. The mainline sm8550-adsp-pas driver
 * loads Samsung's own signed PAS firmware (adsp.mdt + adsp_dtb.mdt) through
 * TrustZone PAS. The bootloader-unlocked posture does not weaken peripheral
 * firmware authentication: the signature roots in Samsung's QFPROM-burned
 * ECDSA384 ROOT 77, so PAS authenticates the genuine stock blob the fuses
 * expect. The memory-region phandles (adspslpi_mem + q6_adsp_dtb_mem) already
 * resolve to the gts9u-correct carveouts declared in /reserved-memory above.
 *
 * firmware-name index 0 = the ADSP image, index 1 = the ADSP DTB image
 * (sm8550_adsp_resource sets dtb_firmware_name; both blobs are required).
 */
&remoteproc_adsp {
	status = "okay";
	firmware-name = "qcom/sm8550/samsung/gts9u/adsp.mdt",
			"qcom/sm8550/samsung/gts9u/adsp_dtb.mdt";
};

/*
 * IRIS video decoder -- the SM8550 hardware codec. Without this node enabled no
 * /dev/video* exists at all and every frame is decoded on the CPU.
 *
 * Upstream ships this node status = "disabled" in sm8550.dtsi with the comment
 * "IRIS firmware is signed by vendors, only enable on boards where the proper
 * signed firmware is available", and flips it to "okay" only on Qualcomm's own
 * reference boards (sm8550-qrd/hdk/mtp). That is a firmware-provenance decision,
 * not a technical limitation -- everything else in the node is already correct
 * for this silicon.
 *
 * WHY firmware-name IS MANDATORY HERE, not merely preferred. The driver's
 * compiled-in default is "qcom/vpu/vpu30_p4.mbn", which linux-firmware resolves
 * (via a WHENCE Link: directive, at install time) to vpu30_p4_s7.mbn. That file's
 * certificate chain reads:
 *     O = QUALCOMM, OU = General Use Test Key (for testing only),
 *     CN = SECTOOLS SECP384R1 CURVE TEST ROOT
 * It is Qualcomm's public TEST key, so it cannot authenticate against any retail
 * device's fused root of trust. Samsung's own vpu30_4v.mbn instead chains to
 *     Samsung Electronics Co., Ltd. / ECDSA384 ROOT 77 -> CA 77 -> ATTEST 77
 * which is byte-identical to the chain on adsp.mdt -- the blob that already
 * authenticates on this device. Both chains were read directly from the images.
 * The device-specific path also stops a stock linux-firmware-qcom install from
 * shadowing it, the same reasoning as a740_zap.mbn above.
 *
 * SIZE: the mainline video_mem carveout is 0x700000 (7 MiB) and matches Samsung's
 * own kalama.dtsi exactly (same base 0x9bb00000, same size, same no-map), so no
 * carveout override is needed. readelf on the blobs confirms the pairing rather
 * than assuming it: vpu30_4v.mbn's final LOAD sits at 0x006ff000 (7 MiB span)
 * while vpu30_4v_16mb.mbn's sits at 0x00fff000 (16 MiB) -- "_16mb" denotes the
 * carveout the image was built for, and that larger variant would not fit here.
 *
 * FAILURE MODE: iris_probe() does not load firmware. It registers two V4L2 nodes
 * and returns; iris_core_init() -- which calls iris_fw_load() and then
 * qcom_scm_pas_auth_and_reset() -- runs from iris_open() only. So a firmware or
 * signature problem surfaces as an open() failure, not a boot failure, and the
 * wait is bounded by HW_RESPONSE_TIMEOUT_VALUE (1000 ms). Note the first open is
 * unlikely to be a deliberate one: WirePlumber's V4L2 monitor enumerates
 * /dev/video* on udev events, so the first PAS attempt fires at session start and
 * its log line is the authoritative one.
 */
&iris {
	status = "okay";
	firmware-name = "qcom/sm8550/samsung/gts9u/vpu30_4v.mbn";
};

/*
 * PMIC GLINK -- the OS-side interface to the PMIC firmware service that runs on
 * the ADSP. A bare node (no USB-C connector graph yet) is sufficient for the
 * battery client (qcom_battmgr -> /sys/class/power_supply). The Type-C
 * connector + usb-role-switch + DP-altmode graph is a later increment.
 */
/ {
	pmic_glink: pmic-glink {
		compatible = "qcom,sm8550-pmic-glink", "qcom,pmic-glink";
	};
};

/*
 * Digital microphones -- PDM parts on the LPASS LPI pins.
 *
 * TRANSPORT. Stock declares SoundWire microphones and switches every one of
 * them off: in this device's own dtbo, va_swr_master and all four
 * dmic_swr@5835022x carry status = "disabled", and qcom,is-used-swr-gpio is 0.
 * The microphones are PDM parts clocked straight off the LPI pins.
 *
 * PINS. Stock enables three clock/data pairs and disables the fourth:
 *
 *     group    clk         data        drive-strength   cdc_dmicNN_pinctrl
 *     dmic01   LPI gpio6   LPI gpio7   2                enabled
 *     dmic23   LPI gpio8   LPI gpio9   2                enabled
 *     dmic45   LPI gpio12  LPI gpio13  2                enabled
 *     dmic67   LPI gpio17  LPI gpio18  8                DISABLED
 *
 * and its sound node references only the dmic01/23/45 pinctrl phandles.
 * Mainline's LPI pinctrl driver maps the identical pins under its own function
 * names -- pinctrl-sm8550-lpass-lpi.c gives dmic1_clk = gpio6, dmic1_data =
 * gpio7, dmic2 = gpio8/9, dmic3 = gpio12/13, dmic4 = gpio17/18 -- so the pins
 * transcribe without translation.
 *
 * WHY THESE STATES ARE BOARD-LOCAL. sm8550.dtsi already carries dmic01_default
 * and dmic23_default, but at drive-strength 8, and it carries no dmic45 state
 * at all. This device drives all three enabled pairs at 2 mA. Matching stock is
 * not negotiable here and a shared SoC dtsi is the wrong place to change it, so
 * the states are defined here and the dtsi's are left untouched.
 *
 * HOW MANY MICROPHONES. Three, not six. A clk/data pair is a CLOCK DOMAIN, not
 * a microphone slot: each pair can carry two PDM parts, one per clock edge, and
 * this device populates the ODD index of each pair. Its own HAL says so
 * directly -- the vendor mixer_paths.xml maps main-mic -> TX DMIC MUX0 = DMIC1,
 * sub-mic -> MUX1 = DMIC3, 3rd-mic -> MUX2 = DMIC5, and every quad-mic path
 * (unprocessed-quad-mic, va-mic-qmic, va-mic-qmic-lpi) is an EMPTY path. The
 * 4th-mic -> DMIC7 entry is inherited boilerplate: its pins are the disabled
 * pair. Counting enabled pin pairs would give six and wire DMIC0/2/4, which are
 * the edges this device does not populate.
 *
 * CLOCK. Stock runs the microphones at two rates and they are not
 * interchangeable:
 *
 *     qcom,va-dmic-sample-rate =  600000   VA macro   low-power, always-on
 *     qcom,tx-dmic-sample-rate = 2400000   TX macro   ordinary recording
 *
 * Across the whole vendor mixer_paths.xml, DMIC_RATE OVERRIDE = CLK_0P6MHZ is
 * set exactly twice, on vr-lowpower-main-mic and vr-lowpower-dual-mic. Every
 * ordinary capture path -- rec-main-mic, camcorder-*, call-*, voip-comm-*,
 * loopback-*, handset-mic, speaker-mic -- runs at the TX macro's default. So
 * 600 kHz is stock's documented low-power exception and 2.4 MHz is what its
 * microphones see when something is actually being recorded; a desktop capture
 * device matching stock wants the latter at the mic's clock pin.
 *
 * Mainline accepts it: va_macro_validate_dmic_sample_rate() divides
 * VA_MACRO_MCLK_FREQ (9600000) by this property, and 9600000 / 2400000 = 4 is
 * VA_MACRO_CLK_DIV_4, an enumerated case. The property is mandatory -- the
 * driver dev_err()s when it is absent.
 */
&lpass_vamacro {
	pinctrl-names = "default";
	pinctrl-0 = <&dmic01_active>, <&dmic23_active>, <&dmic45_active>;

	vdd-micb-supply = <&vreg_l10b_1p8>;
	qcom,dmic-sample-rate = <2400000>;
};

&lpass_tlmm {
	dmic01_active: dmic01-active-state {
		clk-pins {
			pins = "gpio6";
			function = "dmic1_clk";
			drive-strength = <2>;
			output-high;
		};

		data-pins {
			pins = "gpio7";
			function = "dmic1_data";
			drive-strength = <2>;
			input-enable;
		};
	};

	dmic23_active: dmic23-active-state {
		clk-pins {
			pins = "gpio8";
			function = "dmic2_clk";
			drive-strength = <2>;
			output-high;
		};

		data-pins {
			pins = "gpio9";
			function = "dmic2_data";
			drive-strength = <2>;
			input-enable;
		};
	};

	dmic45_active: dmic45-active-state {
		clk-pins {
			pins = "gpio12";
			function = "dmic3_clk";
			drive-strength = <2>;
			output-high;
		};

		data-pins {
			pins = "gpio13";
			function = "dmic3_data";
			drive-strength = <2>;
			input-enable;
		};
	};
};
